* Circuit, read from the shapes
.subckt gf180mcu_as_sc_mcu7t3v3__oa21_4 A B C VDD VNW VSS Y
XM1 VSS A n1 VSUBS nfet_03v3 w=1u l=0.28u
XM2 n1 B VSS VSUBS nfet_03v3 w=1u l=0.28u
XM3 n2 C n1 VSUBS nfet_03v3 w=1u l=0.28u
XM4 Y n2 VSS VSUBS nfet_03v3 w=1u l=0.28u m=4
XM5 n3 A VDD VNW pfet_03v3 w=1.38u l=0.28u
XM6 n2 B n3 VNW pfet_03v3 w=1.38u l=0.28u
XM7 VDD C n2 VNW pfet_03v3 w=1.38u l=0.28u
XM8 Y n2 VDD VNW pfet_03v3 w=1.38u l=0.28u m=4
.ends

# Layout, gdstk code
import gdstk
lib = gdstk.Library(unit=1e-6, precision=1e-09)
def R(c, l, rs):  # rectangles x0, y0, x1, y1
    for r in rs: c.add(gdstk.rectangle(r[:2], r[2:], *l))
def A(c, l, x, y, w, h, nx, ny, dx, dy):  # array of equal rectangles
    R(c, l, [(x+i*dx, y+j*dy, x+i*dx+w, y+j*dy+h) for i in range(nx) for j in range(ny)])
boundary = (0, 0)
nwell = (21, 0)
nwell_10 = (21, 10)
comp = (22, 0)
poly2 = (30, 0)
pplus = (31, 0)
nplus = (32, 0)
contact = (33, 0)
metal1 = (34, 0)
metal1_pin = (34, 10)
lvpwell = (204, 0)
lvpwell_10 = (204, 10)

gf180mcu_as_sc_mcu7t3v3_ = lib.new_cell('gf180mcu_as_sc_mcu7t3v3__oa21_4')
R(gf180mcu_as_sc_mcu7t3v3_, boundary, [(0,0,7.28,3.92)])
R(gf180mcu_as_sc_mcu7t3v3_, nwell, [(-0.43,1.77,7.71,4.35)])
R(gf180mcu_as_sc_mcu7t3v3_, nwell_10, [(0.05,3.67,0.55,4.17)])
R(gf180mcu_as_sc_mcu7t3v3_, comp, [(0.14,0.34,2.9,1.34), (3.18,0.34,6.755,1.34), (0.14,2.2,2.9,3.58), (3.18,2.2,6.755,3.58)])
A(gf180mcu_as_sc_mcu7t3v3_, poly2, 3.62, 0.12, 0.28, 1.46, 4, 1, 0.8, 0)
A(gf180mcu_as_sc_mcu7t3v3_, poly2, 3.62, 1.94, 0.28, 1.86, 4, 1, 0.8, 0)
R(gf180mcu_as_sc_mcu7t3v3_, poly2, [(0.58,0.12,0.86,1.585), (1.38,0.12,1.66,1.61), (2.18,0.12,2.46,1.595), (2.875,1.58,6.3,1.94), (0.375,1.585,0.86,1.945), (1.975,1.595,2.46,1.955), (1.175,1.61,1.66,1.97), (0.58,1.945,0.86,3.8), (2.18,1.955,2.46,3.8), (1.38,1.97,1.66,3.8)])
R(gf180mcu_as_sc_mcu7t3v3_, pplus, [(-0.08,1.77,7.36,4.15)])
R(gf180mcu_as_sc_mcu7t3v3_, nplus, [(-0.08,-0.23,7.36,1.77)])
A(gf180mcu_as_sc_mcu7t3v3_, contact, 3.25, 2.31, 0.22, 0.22, 3, 3, 1.6, 0.47)
R(gf180mcu_as_sc_mcu7t3v3_, contact, [(1.01,0.41,1.23,0.63), (3.25,0.41,3.47,0.63), (4.85,0.495,5.07,0.715), (6.45,0.495,6.67,0.715), (1.81,0.8,2.03,1.02), (0.21,0.955,0.43,1.175), (4.85,0.965,5.07,1.185), (6.45,0.965,6.67,1.185), (5.65,1.015,5.87,1.235), (2.61,1.05,2.83,1.27), (4.05,1.05,4.27,1.27), (2.945,1.65,3.165,1.87), (0.445,1.655,0.665,1.875), (2.045,1.665,2.265,1.885), (1.245,1.68,1.465,1.9), (4.05,2.27,4.27,2.49), (5.65,2.285,5.87,2.505), (1.81,2.635,2.03,2.855), (0.21,2.71,0.43,2.93), (0.21,3.18,0.43,3.4), (2.61,3.29,2.83,3.51)])
A(gf180mcu_as_sc_mcu7t3v3_, metal1, 3.245, 2.18, 0.23, 1.44, 3, 1, 1.6, 0)
R(gf180mcu_as_sc_mcu7t3v3_, metal1, [(0,-0.3,7.28,0.3), (1.005,0.3,1.235,0.69), (3.245,0.3,3.475,0.69), (4.845,0.3,5.075,1.36), (6.445,0.3,6.675,1.36), (1.805,0.7,2.035,0.95), (0.205,0.895,0.435,0.95), (3.98,0.9,4.34,1.59), (5.605,0.9,5.965,1.59), (0.205,0.95,2.035,1.18), (2.605,0.99,2.835,1.58), (0.205,1.18,0.435,1.245), (1.905,1.52,2.275,2.04), (0.34,1.57,0.71,2.09), (1.11,1.575,1.48,2.095), (2.605,1.58,3.19,1.94), (3.98,1.59,5.965,1.895), (3.98,1.895,4.34,2.57), (5.605,1.895,5.965,2.57), (2.605,1.94,2.835,2.505), (1.11,2.095,1.365,3.045), (1.805,2.505,2.835,2.735), (0.205,2.54,0.435,3.62), (1.805,2.735,2.035,2.915), (2.605,3.23,2.835,3.62), (0,3.62,7.28,4.22)])
R(gf180mcu_as_sc_mcu7t3v3_, metal1_pin, [(0,-0.3,7.28,0.3), (3.98,0.9,4.34,2.57), (5.605,0.9,5.965,2.57), (1.905,1.52,2.275,2.04), (0.34,1.57,0.71,2.09), (1.11,1.575,1.48,2.095), (0,3.62,7.28,4.22)])
R(gf180mcu_as_sc_mcu7t3v3_, lvpwell, [(-0.43,-0.43,7.71,1.77)])
R(gf180mcu_as_sc_mcu7t3v3_, lvpwell_10, [(0.05,-0.25,0.55,0.25)])
gf180mcu_as_sc_mcu7t3v3_.add(gdstk.Label('VDD', (3.64,3.92), layer=34, texttype=10))
gf180mcu_as_sc_mcu7t3v3_.add(gdstk.Label('VSS', (3.64,0), layer=34, texttype=10))
gf180mcu_as_sc_mcu7t3v3_.add(gdstk.Label('A', (0.525,1.83), layer=34, texttype=10))
gf180mcu_as_sc_mcu7t3v3_.add(gdstk.Label('B', (1.295,1.835), layer=34, texttype=10))
gf180mcu_as_sc_mcu7t3v3_.add(gdstk.Label('C', (2.09,1.78), layer=34, texttype=10))
gf180mcu_as_sc_mcu7t3v3_.add(gdstk.Label('Y', (5.785,1.735), layer=34, texttype=10))
gf180mcu_as_sc_mcu7t3v3_.add(gdstk.Label('Y', (4.16,1.735), layer=34, texttype=10))
gf180mcu_as_sc_mcu7t3v3_.add(gdstk.Label('VNW', (0.3,3.92), layer=21, texttype=10))
gf180mcu_as_sc_mcu7t3v3_.add(gdstk.Label('VPW', (0.3,0), layer=204, texttype=10))

lib.write_gds('gf180mcu_as_sc_mcu7t3v3__oa21_4.gds')
