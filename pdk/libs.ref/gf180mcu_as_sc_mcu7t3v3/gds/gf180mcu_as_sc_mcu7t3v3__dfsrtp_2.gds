* Circuit, read from the shapes
.subckt gf180mcu_as_sc_mcu7t3v3__dfsrtp_2 CLK D Q RN SN VDD VNW VSS
XM1 VSS CLK n1 VSUBS nfet_03v3 w=1u l=0.28u
XM2 n2 n1 VSS VSUBS nfet_03v3 w=1u l=0.28u
XM3 n3 D VSS VSUBS nfet_03v3 w=1u l=0.28u
XM4 n4 n1 n3 VSUBS nfet_03v3 w=1u l=0.28u
XM5 n5 n2 n4 VSUBS nfet_03v3 w=1u l=0.28u
XM6 n6 n7 n5 VSUBS nfet_03v3 w=1u l=0.28u
XM7 VSS RN n6 VSUBS nfet_03v3 w=1u l=0.28u
XM8 n8 n4 VSS VSUBS nfet_03v3 w=1u l=0.28u
XM9 n7 SN n8 VSUBS nfet_03v3 w=1u l=0.28u
XM10 n9 n2 n7 VSUBS nfet_03v3 w=1u l=0.28u
XM11 n10 n1 n9 VSUBS nfet_03v3 w=1u l=0.28u
XM12 n11 SN n10 VSUBS nfet_03v3 w=1u l=0.28u
XM13 VSS n12 n11 VSUBS nfet_03v3 w=1u l=0.28u
XM14 n13 RN VSS VSUBS nfet_03v3 w=1u l=0.28u
XM15 n12 n9 n13 VSUBS nfet_03v3 w=1u l=0.28u
XM16 Q n12 VSS VSUBS nfet_03v3 w=1u l=0.28u m=2
XM17 VDD CLK n1 VNW pfet_03v3 w=1.38u l=0.28u
XM18 n2 n1 VDD VNW pfet_03v3 w=1.38u l=0.28u
XM19 n3 D VDD VNW pfet_03v3 w=1.38u l=0.285u
XM20 n4 n2 n3 VNW pfet_03v3 w=1.38u l=0.28u
XM21 n14 n1 n4 VNW pfet_03v3 w=1.38u l=0.285u
XM22 VDD n7 n14 VNW pfet_03v3 w=1.38u l=0.28u
XM23 n14 RN VDD VNW pfet_03v3 w=1.38u l=0.28u
XM24 VDD n4 n7 VNW pfet_03v3 w=1.38u l=0.28u
XM25 n7 SN VDD VNW pfet_03v3 w=1.38u l=0.28u
XM26 n9 n1 n7 VNW pfet_03v3 w=1.38u l=0.28u
XM27 n10 n2 n9 VNW pfet_03v3 w=1.38u l=0.28u
XM28 n10 SN VDD VNW pfet_03v3 w=1.38u l=0.28u
XM29 VDD n12 n10 VNW pfet_03v3 w=1.38u l=0.28u
XM30 n12 RN VDD VNW pfet_03v3 w=1.38u l=0.28u
XM31 VDD n9 n12 VNW pfet_03v3 w=1.38u l=0.28u
XM32 Q n12 VDD VNW pfet_03v3 w=1.38u l=0.28u m=2
.ends

# Layout, gdstk code
import gdstk
lib = gdstk.Library(unit=1e-6, precision=1e-09)
def R(c, l, rs):  # rectangles x0, y0, x1, y1
    for r in rs: c.add(gdstk.rectangle(r[:2], r[2:], *l))
def A(c, l, x, y, w, h, nx, ny, dx, dy):  # array of equal rectangles
    R(c, l, [(x+i*dx, y+j*dy, x+i*dx+w, y+j*dy+h) for i in range(nx) for j in range(ny)])
boundary = (0, 0)
nwell = (21, 0)
nwell_10 = (21, 10)
comp = (22, 0)
poly2 = (30, 0)
pplus = (31, 0)
nplus = (32, 0)
contact = (33, 0)
metal1 = (34, 0)
metal1_pin = (34, 10)
via1 = (35, 0)
metal2 = (36, 0)
lvpwell = (204, 0)
lvpwell_10 = (204, 10)

gf180mcu_as_sc_mcu7t3v3_ = lib.new_cell('gf180mcu_as_sc_mcu7t3v3__dfsrtp_2')
R(gf180mcu_as_sc_mcu7t3v3_, boundary, [(0,0,20.72,3.92)])
R(gf180mcu_as_sc_mcu7t3v3_, nwell, [(-0.43,1.77,21.15,4.35)])
R(gf180mcu_as_sc_mcu7t3v3_, nwell_10, [(0.05,3.67,0.55,4.17)])
R(gf180mcu_as_sc_mcu7t3v3_, comp, [(0.14,0.34,2.145,1.34), (2.425,0.34,13.465,1.34), (13.865,0.34,18.065,1.34), (18.445,0.34,20.58,1.34), (0.14,2.2,2.145,3.58), (2.425,2.2,8.315,3.58), (8.595,2.2,13.44,3.58), (13.935,2.2,18.155,3.58), (18.445,2.2,20.58,3.58)])
R(gf180mcu_as_sc_mcu7t3v3_, poly2, [(0.58,0.12,0.86,1.6), (1.38,0.12,1.66,1.595), (2.915,0.12,3.195,1.63), (4.435,0.12,4.715,1.56), (6.29,0.12,6.57,1.44), (6.87,0.12,7.15,1.495), (7.58,0.12,7.86,1.495), (8.69,0.12,8.97,1.625), (9.78,0.12,10.06,1.625), (11.02,0.12,11.3,1.44), (11.955,0.12,12.235,1.625), (14.475,0.12,14.755,1.625), (15.31,0.12,15.59,1.615), (16.35,0.12,16.63,1.44), (17.28,0.12,17.56,1.74), (18.885,0.12,19.165,1.62), (19.685,0.12,19.965,1.62), (6.25,1.44,6.61,1.8), (10.98,1.44,11.34,1.8), (16.27,1.44,16.63,1.8), (6.87,1.495,7.23,1.855), (7.58,1.495,7.945,1.855), (4.405,1.56,4.765,1.92), (1.11,1.595,1.66,1.965), (0.5,1.6,0.86,1.97), (15.31,1.615,15.765,1.975), (18,1.62,19.965,1.98), (8.69,1.625,9.385,1.965), (9.78,1.625,10.38,1.89), (11.62,1.625,12.235,1.985), (14.375,1.625,14.755,1.985), (2.885,1.63,3.245,1.99), (5.305,1.63,5.685,1.99), (12.545,1.72,12.925,2.08), (3.805,1.74,4.165,2.1), (17.28,1.74,17.66,2.1), (16.35,1.8,16.63,3.8), (6.87,1.855,7.15,1.975), (7.58,1.855,7.86,3.8), (10,1.89,10.38,1.985), (1.38,1.965,1.66,3.8), (9.035,1.965,9.385,1.985), (0.58,1.97,0.86,3.8), (6.78,1.975,7.15,2.095), (15.41,1.975,15.69,3.8), (18.885,1.98,19.165,3.8), (19.685,1.98,19.965,3.8), (9.035,1.985,9.315,3.8), (10.045,1.985,10.325,3.8), (11.62,1.985,11.9,3.8), (14.475,1.985,14.755,3.8), (2.94,1.99,3.225,3.8), (5.305,1.99,5.59,3.8), (12.545,2.08,12.825,3.8), (6.78,2.095,7.06,3.8), (3.885,2.1,4.165,3.8), (17.28,2.1,17.56,3.8)])
R(gf180mcu_as_sc_mcu7t3v3_, pplus, [(-0.08,1.77,20.8,4.15)])
R(gf180mcu_as_sc_mcu7t3v3_, nplus, [(-0.08,-0.23,20.8,1.77)])
A(gf180mcu_as_sc_mcu7t3v3_, contact, 17.865, 2.31, 0.22, 0.22, 1, 3, 0, 0.47)
A(gf180mcu_as_sc_mcu7t3v3_, contact, 18.515, 2.31, 0.22, 0.22, 1, 3, 0, 0.47)
A(gf180mcu_as_sc_mcu7t3v3_, contact, 20.115, 2.31, 0.22, 0.22, 1, 3, 0, 0.47)
R(gf180mcu_as_sc_mcu7t3v3_, contact, [(1.01,0.41,1.23,0.63), (2.495,0.41,2.715,0.63), (8.26,0.41,8.48,0.63), (15.98,0.41,16.2,0.63), (18.515,0.495,18.735,0.715), (20.115,0.495,20.335,0.715), (19.315,0.82,19.535,1.04), (17.775,0.905,17.995,1.125), (18.515,0.965,18.735,1.185), (20.115,0.965,20.335,1.185), (0.21,1.05,0.43,1.27), (1.81,1.05,2.03,1.27), (3.415,1.05,3.635,1.27), (4.935,1.05,5.155,1.27), (10.495,1.05,10.715,1.27), (11.585,1.05,11.805,1.27), (13.175,1.05,13.395,1.27), (14.05,1.05,14.27,1.27), (6.32,1.51,6.54,1.73), (11.05,1.51,11.27,1.73), (16.34,1.51,16.56,1.73), (6.94,1.565,7.16,1.785), (7.655,1.565,7.875,1.785), (4.475,1.63,4.695,1.85), (1.18,1.665,1.4,1.885), (0.57,1.67,0.79,1.89), (15.47,1.685,15.69,1.905), (18.165,1.69,18.385,1.91), (18.635,1.69,18.855,1.91), (9.095,1.695,9.315,1.915), (10.08,1.695,10.3,1.915), (11.7,1.695,11.92,1.915), (14.445,1.695,14.665,1.915), (2.955,1.7,3.175,1.92), (5.395,1.7,5.615,1.92), (12.625,1.79,12.845,2.01), (3.875,1.81,4.095,2.03), (17.37,1.81,17.59,2.03), (1.81,2.27,2.03,2.49), (10.55,2.27,10.77,2.49), (13.06,2.28,13.28,2.5), (4.935,2.445,5.155,2.665), (16.855,2.455,17.075,2.675), (19.315,2.455,19.535,2.675), (12.16,2.47,12.38,2.69), (15.01,2.475,15.23,2.695), (3.47,2.495,3.69,2.715), (0.21,2.71,0.43,2.93), (5.915,2.885,6.135,3.105), (8.665,2.885,8.885,3.105), (8.01,2.9,8.23,3.12), (19.315,2.925,19.535,3.145), (12.16,2.94,12.38,3.16), (14.09,3.28,14.31,3.5), (15.935,3.285,16.155,3.505), (1.01,3.29,1.23,3.51), (2.495,3.29,2.715,3.51), (7.21,3.29,7.43,3.51), (9.55,3.29,9.77,3.51)])
R(gf180mcu_as_sc_mcu7t3v3_, metal1, [(0,-0.3,20.72,0.3), (1.005,0.3,1.235,0.69), (2.49,0.3,2.72,0.69), (8.195,0.3,8.55,0.635), (15.9,0.3,16.315,0.635), (18.51,0.3,18.74,1.39), (20.11,0.3,20.34,1.385), (2.95,0.53,6.545,0.76), (9.505,0.53,15.67,0.76), (19.215,0.53,19.645,3.39), (17.77,0.705,18,1.345), (2.95,0.76,3.18,0.94), (3.87,0.76,4.1,2.1), (6.315,0.76,6.545,1.085), (9.505,0.76,9.735,1.065), (15.435,0.76,15.67,0.88), (15.435,0.88,16.62,1.115), (1.8,0.94,3.18,1.17), (0.205,0.99,0.435,1.045), (3.41,0.99,3.64,2.285), (4.93,0.99,5.16,1.135), (11.03,0.99,11.29,1.8), (12.62,1.01,12.88,1.39), (0.205,1.045,1.335,1.275), (10.435,1.045,10.795,1.275), (11.52,1.045,12.385,1.275), (13.11,1.045,15.2,1.325), (8.5,1.065,9.735,1.295), (7.17,1.07,7.55,1.085), (6.315,1.085,7.55,1.315), (15.955,1.115,16.62,1.99), (4.93,1.135,6.08,1.365), (1.805,1.17,2.035,2.265), (0.205,1.275,0.435,1.33), (1.105,1.275,1.335,1.605), (10.535,1.275,10.795,2.55), (12.155,1.275,12.385,2.74), (8.5,1.295,8.73,1.56), (6.315,1.315,6.545,1.835), (7.17,1.315,7.55,1.33), (13.11,1.325,13.34,2.275), (14.97,1.325,15.2,1.665), (16.85,1.345,18.28,1.575), (4.93,1.365,5.16,2.9), (5.85,1.365,6.08,2.365), (12.62,1.39,12.85,2.08), (2.345,1.4,3.18,2.535), (6.835,1.56,7.22,2.015), (7.595,1.56,8.73,1.79), (9.035,1.56,9.355,2.025), (13.575,1.565,14.725,2.51), (4.47,1.57,4.7,2.195), (16.85,1.575,17.08,2.235), (18.05,1.575,18.28,1.685), (0.125,1.6,0.86,2.06), (1.105,1.605,1.405,1.985), (15.465,1.615,15.695,2.235), (10.075,1.625,10.305,2.81), (11.695,1.625,11.925,2.03), (5.39,1.63,5.62,3.16), (9.585,1.635,9.845,2.015), (14.97,1.665,15.235,1.92), (18.05,1.685,18.955,1.915), (17.31,1.805,17.65,2.035), (15.005,1.92,15.235,2.92), (1.105,1.985,1.335,2.705), (9.6,2.015,9.83,2.825), (9.055,2.025,9.285,2.365), (11.025,2.03,11.925,2.29), (17.31,2.035,17.54,3.16), (17.86,2.145,18.09,3.62), (18.51,2.145,18.74,3.62), (20.11,2.145,20.34,3.62), (4.44,2.195,4.7,2.575), (15.465,2.235,17.08,2.465), (1.745,2.265,2.095,2.495), (13,2.275,13.34,2.505), (3.41,2.285,3.695,2.53), (11.025,2.29,11.285,2.58), (5.85,2.365,9.285,2.595), (16.85,2.465,17.08,2.925), (11.65,2.52,11.91,2.57), (3.465,2.53,3.695,2.925), (11.65,2.57,11.925,2.81), (4.47,2.575,4.7,3.16), (0.205,2.65,0.445,2.705), (0.205,2.705,1.335,2.77), (15.47,2.735,16.62,2.965), (12.155,2.74,14.775,2.97), (0.205,2.77,3.23,2.935), (10.075,2.81,11.925,2.835), (5.91,2.825,8.235,3.055), (8.66,2.825,9.83,3.055), (10.075,2.835,11.91,3.04), (0.205,2.935,0.445,2.995), (1.105,2.935,3.23,3), (15.47,2.965,15.7,3.15), (16.39,2.965,16.62,3.16), (12.155,2.97,12.385,3.39), (14.545,2.97,14.775,3.15), (3,3,3.23,3.16), (5.91,3.055,6.14,3.17), (8.005,3.055,8.235,3.18), (8.66,3.055,8.89,3.165), (14.545,3.15,15.7,3.38), (3,3.16,5.62,3.39), (16.39,3.16,17.54,3.39), (14.085,3.2,14.315,3.62), (15.93,3.21,16.16,3.62), (1.005,3.23,1.235,3.62), (2.49,3.23,2.72,3.62), (7.12,3.285,7.54,3.62), (9.48,3.285,9.845,3.62), (0,3.62,20.72,4.22)])
R(gf180mcu_as_sc_mcu7t3v3_, metal1_pin, [(0,-0.3,20.72,0.3), (19.215,0.53,19.645,3.39), (15.955,0.88,16.62,1.99), (2.345,1.4,3.18,2.535), (13.575,1.565,14.725,2.51), (0.125,1.6,0.86,2.06), (0,3.62,20.72,4.22)])
R(gf180mcu_as_sc_mcu7t3v3_, via1, [(7.23,1.07,7.49,1.33), (11.03,1.07,11.29,1.33), (12.62,1.07,12.88,1.33), (13.645,1.69,13.905,1.95), (6.89,1.695,7.15,1.955), (9.585,1.695,9.845,1.955), (10.535,1.695,10.795,1.955), (4.44,2.255,4.7,2.515), (11.025,2.26,11.285,2.52), (11.65,2.58,11.91,2.84)])
R(gf180mcu_as_sc_mcu7t3v3_, metal2, [(7.17,1.055,7.51,1.06), (7.17,1.06,12.945,1.34), (6.83,1.68,10.855,1.965), (11.645,1.68,13.965,1.96), (11.645,1.96,11.925,2.56), (4.38,2.245,11.35,2.53), (11.635,2.56,11.925,2.9)])
R(gf180mcu_as_sc_mcu7t3v3_, lvpwell, [(-0.43,-0.43,21.15,1.77)])
R(gf180mcu_as_sc_mcu7t3v3_, lvpwell_10, [(0.05,-0.25,0.55,0.25)])
gf180mcu_as_sc_mcu7t3v3_.add(gdstk.Label('VDD', (10.36,3.92), layer=34, texttype=10))
gf180mcu_as_sc_mcu7t3v3_.add(gdstk.Label('VNW', (0.3,3.92), layer=21, texttype=10))
gf180mcu_as_sc_mcu7t3v3_.add(gdstk.Label('VPW', (0.3,0), layer=204, texttype=10))
gf180mcu_as_sc_mcu7t3v3_.add(gdstk.Label('VSS', (10.36,0), layer=34, texttype=10))
gf180mcu_as_sc_mcu7t3v3_.add(gdstk.Label('CLK', (0.492,1.83), layer=34, texttype=10))
gf180mcu_as_sc_mcu7t3v3_.add(gdstk.Label('Q', (19.43,1.96), layer=34, texttype=10))
gf180mcu_as_sc_mcu7t3v3_.add(gdstk.Label('RN', (16.287,1.435), layer=34, texttype=10))
gf180mcu_as_sc_mcu7t3v3_.add(gdstk.Label('SN', (14.15,2.037), layer=34, texttype=10))
gf180mcu_as_sc_mcu7t3v3_.add(gdstk.Label('D', (2.762,1.967), layer=34, texttype=10))

lib.write_gds('gf180mcu_as_sc_mcu7t3v3__dfsrtp_2.gds')
