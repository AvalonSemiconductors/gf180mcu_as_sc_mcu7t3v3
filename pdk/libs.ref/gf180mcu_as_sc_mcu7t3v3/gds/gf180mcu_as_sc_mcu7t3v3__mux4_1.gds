* Circuit, read from the shapes
.subckt gf180mcu_as_sc_mcu7t3v3__mux4_1 A B C D S0 S1 VDD VNW VSS Y
XM1 n1 C VSS VSUBS nfet_03v3 w=1u l=0.28u
XM2 n2 n3 n1 VSUBS nfet_03v3 w=1u l=0.28u
XM3 n4 S0 n2 VSUBS nfet_03v3 w=1u l=0.28u
XM4 VSS D n4 VSUBS nfet_03v3 w=1u l=0.28u
XM5 Y n5 VSS VSUBS nfet_03v3 w=1u l=0.28u
XM6 n5 S1 n2 VSUBS nfet_03v3 w=1u l=0.28u
XM7 n6 n7 n5 VSUBS nfet_03v3 w=1u l=0.28u
XM8 VSS S1 n7 VSUBS nfet_03v3 w=1u l=0.28u
XM9 n8 B VSS VSUBS nfet_03v3 w=1u l=0.28u
XM10 n6 S0 n8 VSUBS nfet_03v3 w=1u l=0.28u
XM11 n9 n3 n6 VSUBS nfet_03v3 w=1u l=0.28u
XM12 VSS A n9 VSUBS nfet_03v3 w=1u l=0.28u
XM13 n3 S0 VSS VSUBS nfet_03v3 w=1u l=0.28u
XM14 n1 C VDD VNW pfet_03v3 w=1.38u l=0.28u
XM15 n2 S0 n1 VNW pfet_03v3 w=1.38u l=0.28u
XM16 n4 n3 n2 VNW pfet_03v3 w=1.38u l=0.28u
XM17 VDD D n4 VNW pfet_03v3 w=1.38u l=0.28u
XM18 Y n5 VDD VNW pfet_03v3 w=1.38u l=0.28u
XM19 n5 n7 n2 VNW pfet_03v3 w=1.38u l=0.28u
XM20 n6 S1 n5 VNW pfet_03v3 w=1.38u l=0.28u
XM21 VDD S1 n7 VNW pfet_03v3 w=1.38u l=0.28u
XM22 n8 B VDD VNW pfet_03v3 w=1.38u l=0.28u
XM23 n6 n3 n8 VNW pfet_03v3 w=1.38u l=0.28u
XM24 n9 S0 n6 VNW pfet_03v3 w=1.38u l=0.28u
XM25 VDD A n9 VNW pfet_03v3 w=1.38u l=0.28u
XM26 n3 S0 VDD VNW pfet_03v3 w=1.38u l=0.28u
.ends

# Layout, gdstk code
import gdstk
lib = gdstk.Library(unit=1e-6, precision=1e-09)
def R(c, l, rs):  # rectangles x0, y0, x1, y1
    for r in rs: c.add(gdstk.rectangle(r[:2], r[2:], *l))
boundary = (0, 0)
nwell = (21, 0)
nwell_10 = (21, 10)
comp = (22, 0)
poly2 = (30, 0)
pplus = (31, 0)
nplus = (32, 0)
contact = (33, 0)
metal1 = (34, 0)
metal1_pin = (34, 10)
via1 = (35, 0)
metal2 = (36, 0)
lvpwell = (204, 0)
lvpwell_10 = (204, 10)

gf180mcu_as_sc_mcu7t3v3_ = lib.new_cell('gf180mcu_as_sc_mcu7t3v3__mux4_1')
R(gf180mcu_as_sc_mcu7t3v3_, boundary, [(0,0,17.36,3.92)])
R(gf180mcu_as_sc_mcu7t3v3_, nwell, [(-0.43,1.77,17.79,4.35)])
R(gf180mcu_as_sc_mcu7t3v3_, nwell_10, [(0.05,3.67,0.55,4.17)])
R(gf180mcu_as_sc_mcu7t3v3_, comp, [(0.14,0.34,6.295,1.34), (6.575,0.34,9.97,1.34), (10.25,0.34,17.22,1.34), (0.14,2.2,6.295,3.58), (6.575,2.2,9.97,3.58), (10.25,2.2,17.22,3.58)])
R(gf180mcu_as_sc_mcu7t3v3_, poly2, [(0.58,0.12,0.86,1.55), (1.86,0.12,2.14,1.59), (3.865,0.12,4.145,1.59), (4.775,0.12,5.055,1.6), (5.575,0.12,5.855,1.6), (7.65,0.12,7.93,1.6), (8.45,0.12,8.73,1.6), (10.69,0.12,10.97,1.66), (11.49,0.12,11.77,1.6), (12.33,0.12,12.61,1.605), (13.915,0.12,14.195,1.605), (15.335,0.12,15.615,1.595), (16.145,0.12,16.425,1.6), (0.29,1.55,0.86,2.015), (1.86,1.59,2.22,1.95), (2.46,1.59,2.82,1.95), (3.26,1.59,3.62,1.95), (3.86,1.59,4.22,1.95), (14.435,1.59,14.795,1.95), (8.97,1.595,9.53,1.66), (15.335,1.595,15.905,1.955), (4.775,1.6,5.25,1.96), (5.575,1.6,7.395,1.96), (7.635,1.6,7.995,1.96), (8.25,1.6,8.73,1.96), (11.29,1.6,11.77,1.96), (16.145,1.6,16.64,1.96), (12.31,1.605,12.67,1.965), (12.91,1.605,14.195,1.835), (8.97,1.66,10.97,1.89), (12.91,1.835,13.27,1.965), (8.97,1.89,9.53,1.955), (10.69,1.89,10.97,3.8), (2.54,1.95,2.82,3.8), (3.34,1.95,3.62,3.8), (14.45,1.95,14.73,3.8), (9.25,1.955,9.53,3.8), (15.335,1.955,15.615,3.8), (4.775,1.96,5.055,3.8), (5.575,1.96,5.855,3.8), (8.45,1.96,8.73,3.8), (11.49,1.96,11.77,3.8), (16.145,1.96,16.425,3.8), (12.92,1.965,13.2,3.8), (0.58,2.015,0.86,3.8)])
R(gf180mcu_as_sc_mcu7t3v3_, pplus, [(-0.08,1.77,17.44,4.15)])
R(gf180mcu_as_sc_mcu7t3v3_, nplus, [(-0.08,-0.23,17.44,1.77)])
R(gf180mcu_as_sc_mcu7t3v3_, contact, [(0.21,0.41,0.43,0.63), (5.205,0.41,5.425,0.63), (11.12,0.41,11.34,0.63), (15.765,0.41,15.985,0.63), (8.08,0.535,8.3,0.755), (2.29,0.57,2.51,0.79), (6.005,0.995,6.225,1.215), (1.01,1.05,1.23,1.27), (4.405,1.05,4.625,1.27), (6.645,1.05,6.865,1.27), (9.68,1.05,9.9,1.27), (10.32,1.05,10.54,1.27), (11.92,1.05,12.14,1.27), (13.44,1.05,13.66,1.27), (14.965,1.05,15.185,1.27), (16.81,1.05,17.03,1.27), (1.93,1.66,2.15,1.88), (2.53,1.66,2.75,1.88), (3.33,1.66,3.55,1.88), (3.93,1.66,4.15,1.88), (14.505,1.66,14.725,1.88), (9.04,1.665,9.26,1.885), (15.59,1.665,15.81,1.885), (4.96,1.67,5.18,1.89), (7.105,1.67,7.325,1.89), (7.705,1.67,7.925,1.89), (8.32,1.67,8.54,1.89), (11.36,1.67,11.58,1.89), (16.35,1.67,16.57,1.89), (0.36,1.675,0.58,1.895), (12.38,1.675,12.6,1.895), (12.98,1.675,13.2,1.895), (1.01,2.27,1.23,2.49), (4.405,2.27,4.625,2.49), (6.005,2.27,6.225,2.49), (6.645,2.27,6.865,2.49), (9.68,2.27,9.9,2.49), (10.32,2.27,10.54,2.49), (11.92,2.27,12.14,2.49), (13.44,2.27,13.66,2.49), (14.965,2.27,15.185,2.49), (16.81,2.27,17.03,2.49), (2.97,2.35,3.19,2.57), (8.88,2.775,9.1,2.995), (0.21,3.29,0.43,3.51), (5.205,3.29,5.425,3.51), (11.12,3.29,11.34,3.51), (15.765,3.29,15.985,3.51)])
R(gf180mcu_as_sc_mcu7t3v3_, metal1, [(0,-0.3,17.36,0.3), (0.205,0.3,0.435,0.69), (5.2,0.3,5.43,0.69), (11.115,0.3,11.345,0.69), (15.76,0.3,15.99,0.69), (7.1,0.53,8.36,0.76), (9.215,0.53,10.545,0.76), (1.465,0.565,2.57,0.795), (16.495,0.715,17.035,0.975), (7.1,0.76,7.33,2.77), (9.215,0.76,9.445,0.99), (10.315,0.76,10.545,2.55), (1.465,0.795,1.695,2.345), (16.805,0.975,17.035,2.55), (1.005,0.99,1.235,2.55), (4.4,0.99,4.63,2.265), (5.945,0.99,6.285,1.51), (6.64,0.99,6.87,2.77), (8.315,0.99,9.445,1.22), (9.675,0.99,9.905,2.78), (11.915,0.99,12.145,2.55), (13.435,0.99,13.665,3.02), (14.96,0.99,15.19,2.265), (2.525,1.025,4.155,1.255), (8.315,1.22,8.545,2.08), (12.375,1.24,12.635,1.62), (2.525,1.255,2.875,1.96), (3.925,1.255,4.155,1.58), (7.615,1.47,8.005,2.31), (9.035,1.47,9.265,2.31), (14.445,1.47,14.73,1.985), (16.345,1.47,16.575,2.725), (12.975,1.48,13.205,1.595), (1.925,1.485,2.155,1.58), (3.325,1.485,3.555,1.58), (4.915,1.51,5.325,2.045), (5.62,1.51,6.285,2.05), (0.2,1.545,0.62,2.03), (1.925,1.58,2.185,1.96), (3.31,1.58,3.57,1.96), (3.91,1.58,4.17,1.96), (12.945,1.595,13.205,1.975), (15.42,1.595,15.955,1.955), (10.935,1.6,11.625,1.96), (12.375,1.62,12.605,2.41), (1.925,1.96,2.155,2.115), (2.525,1.96,2.755,2.115), (3.325,1.96,3.555,2.115), (3.925,1.96,4.155,2.115), (12.975,1.975,13.205,2.11), (14.445,1.985,14.675,2.47), (5.945,2.05,6.285,2.495), (4.345,2.265,4.685,2.495), (14.905,2.265,15.245,2.495), (7.615,2.31,9.265,2.375), (1.465,2.345,3.25,2.575), (7.7,2.375,9.265,2.54), (12.375,2.41,12.695,2.79), (13.905,2.47,14.675,2.725), (2.965,2.575,3.25,2.77), (13.905,2.725,16.575,2.73), (14.445,2.73,16.575,2.955), (2.965,2.77,6.87,3), (7.1,2.77,9.16,3), (9.675,2.78,11.87,3.01), (11.635,3.01,11.87,3.02), (11.635,3.02,13.665,3.25), (0.205,3.23,0.435,3.62), (5.2,3.23,5.43,3.62), (15.76,3.23,15.99,3.62), (11.06,3.285,11.4,3.62), (0,3.62,17.36,4.22)])
R(gf180mcu_as_sc_mcu7t3v3_, metal1_pin, [(0,-0.3,17.36,0.3), (2.525,1.025,2.875,1.86), (5.945,1.34,6.285,2.495), (7.615,1.47,8.005,2.375), (4.915,1.51,5.325,2.045), (5.62,1.51,5.945,2.05), (0.2,1.545,0.62,2.03), (15.42,1.595,15.955,1.955), (10.935,1.6,11.625,1.96), (0,3.62,17.36,4.22)])
R(gf180mcu_as_sc_mcu7t3v3_, via1, [(16.555,0.715,16.815,0.975), (12.375,1.3,12.635,1.56), (1.925,1.64,2.185,1.9), (3.31,1.64,3.57,1.9), (3.91,1.64,4.17,1.9), (12.945,1.655,13.205,1.915), (12.375,2.47,12.635,2.73), (13.965,2.47,14.225,2.73)])
R(gf180mcu_as_sc_mcu7t3v3_, metal2, [(3.9,0.705,12.645,0.985), (12.935,0.705,16.875,0.985), (3.9,0.985,4.18,1.96), (12.365,0.985,12.645,1.62), (12.935,0.985,13.215,1.9), (1.915,1.435,2.195,2.34), (3.3,1.58,3.58,2.34), (11.755,1.9,13.215,2.18), (11.755,2.18,12.035,2.895), (1.915,2.34,3.58,2.62), (12.315,2.46,14.285,2.74), (3.3,2.62,3.58,2.895), (3.3,2.895,12.035,3.175)])
R(gf180mcu_as_sc_mcu7t3v3_, lvpwell, [(-0.43,-0.43,17.79,1.77)])
R(gf180mcu_as_sc_mcu7t3v3_, lvpwell_10, [(0.05,-0.25,0.55,0.25)])
gf180mcu_as_sc_mcu7t3v3_.add(gdstk.Label('VDD', (8.68,3.92), layer=34, texttype=10))
gf180mcu_as_sc_mcu7t3v3_.add(gdstk.Label('VNW', (0.3,3.92), layer=21, texttype=10))
gf180mcu_as_sc_mcu7t3v3_.add(gdstk.Label('VPW', (0.3,0), layer=204, texttype=10))
gf180mcu_as_sc_mcu7t3v3_.add(gdstk.Label('VSS', (8.68,0), layer=34, texttype=10))
gf180mcu_as_sc_mcu7t3v3_.add(gdstk.Label('C', (0.41,1.787), layer=34, texttype=10))
gf180mcu_as_sc_mcu7t3v3_.add(gdstk.Label('D', (5.12,1.777), layer=34, texttype=10))
gf180mcu_as_sc_mcu7t3v3_.add(gdstk.Label('Y', (5.782,1.78), layer=34, texttype=10))
gf180mcu_as_sc_mcu7t3v3_.add(gdstk.Label('Y', (6.115,1.917), layer=34, texttype=10))
gf180mcu_as_sc_mcu7t3v3_.add(gdstk.Label('B', (11.28,1.78), layer=34, texttype=10))
gf180mcu_as_sc_mcu7t3v3_.add(gdstk.Label('A', (15.687,1.775), layer=34, texttype=10))
gf180mcu_as_sc_mcu7t3v3_.add(gdstk.Label('S0', (2.7,1.442), layer=34, texttype=10))
gf180mcu_as_sc_mcu7t3v3_.add(gdstk.Label('S1', (7.81,1.922), layer=34, texttype=10))

lib.write_gds('gf180mcu_as_sc_mcu7t3v3__mux4_1.gds')
