* Circuit, read from the shapes
.subckt gf180mcu_as_sc_mcu7t3v3__aoi211_4 A B C D VDD VNW VSS Y
XM1 n1 A VSS VSUBS nfet_03v3 w=1u l=0.28u m=4
XM2 Y B n1 VSUBS nfet_03v3 w=1u l=0.28u m=4
XM3 Y C VSS VSUBS nfet_03v3 w=1u l=0.28u m=4
XM4 VSS D Y VSUBS nfet_03v3 w=1u l=0.28u m=4
XM5 VDD A n2 VNW pfet_03v3 w=1.38u l=0.28u m=4
XM6 n2 B VDD VNW pfet_03v3 w=1.38u l=0.28u m=4
XM7 n3 C n2 VNW pfet_03v3 w=1.38u l=0.28u m=2
XM8 n4 C n2 VNW pfet_03v3 w=1.38u l=0.28u
XM9 Y D n4 VNW pfet_03v3 w=1.38u l=0.28u
XM10 n3 D Y VNW pfet_03v3 w=1.38u l=0.28u m=2
XM11 n5 D Y VNW pfet_03v3 w=1.38u l=0.28u
XM12 n2 C n5 VNW pfet_03v3 w=1.38u l=0.28u
.ends

# Layout, gdstk code
import gdstk
lib = gdstk.Library(unit=1e-6, precision=1e-09)
def R(c, l, rs):  # rectangles x0, y0, x1, y1
    for r in rs: c.add(gdstk.rectangle(r[:2], r[2:], *l))
def A(c, l, x, y, w, h, nx, ny, dx, dy):  # array of equal rectangles
    R(c, l, [(x+i*dx, y+j*dy, x+i*dx+w, y+j*dy+h) for i in range(nx) for j in range(ny)])
boundary = (0, 0)
nwell = (21, 0)
nwell_10 = (21, 10)
comp = (22, 0)
poly2 = (30, 0)
pplus = (31, 0)
nplus = (32, 0)
contact = (33, 0)
metal1 = (34, 0)
metal1_pin = (34, 10)
via1 = (35, 0)
metal2 = (36, 0)
lvpwell = (204, 0)
lvpwell_10 = (204, 10)

gf180mcu_as_sc_mcu7t3v3_ = lib.new_cell('gf180mcu_as_sc_mcu7t3v3__aoi211_4')
R(gf180mcu_as_sc_mcu7t3v3_, boundary, [(0,0,14,3.92)])
R(gf180mcu_as_sc_mcu7t3v3_, nwell, [(-0.43,1.77,14.43,4.35)])
R(gf180mcu_as_sc_mcu7t3v3_, nwell_10, [(0.05,3.67,0.55,4.17)])
R(gf180mcu_as_sc_mcu7t3v3_, comp, [(0.14,0.34,13.3,1.34), (0.14,2.2,13.3,3.58)])
A(gf180mcu_as_sc_mcu7t3v3_, poly2, 0.58, 0.12, 0.28, 1.45, 3, 1, 0.8, 0)
A(gf180mcu_as_sc_mcu7t3v3_, poly2, 2.98, 0.12, 0.28, 1.4, 4, 1, 0.8, 0)
A(gf180mcu_as_sc_mcu7t3v3_, poly2, 6.98, 0.12, 0.28, 1.445, 3, 1, 0.8, 0)
A(gf180mcu_as_sc_mcu7t3v3_, poly2, 9.38, 0.12, 0.28, 1.48, 4, 1, 0.8, 0)
A(gf180mcu_as_sc_mcu7t3v3_, poly2, 6.98, 1.955, 0.28, 1.845, 3, 1, 0.8, 0)
A(gf180mcu_as_sc_mcu7t3v3_, poly2, 2.98, 1.96, 0.28, 1.84, 4, 1, 0.8, 0)
A(gf180mcu_as_sc_mcu7t3v3_, poly2, 9.38, 1.96, 0.28, 1.84, 4, 1, 0.8, 0)
A(gf180mcu_as_sc_mcu7t3v3_, poly2, 0.58, 1.965, 0.28, 1.835, 3, 1, 0.8, 0)
R(gf180mcu_as_sc_mcu7t3v3_, poly2, [(6.18,0.12,6.46,1.59), (12.58,0.12,12.86,1.59), (2.98,1.52,5.66,1.96), (6.98,1.565,8.86,1.955), (0.58,1.57,2.46,1.965), (6.14,1.59,6.5,1.94), (12.54,1.59,12.9,1.94), (9.38,1.6,12.06,1.96), (6.18,1.94,6.46,3.8), (12.58,1.94,12.86,3.8)])
R(gf180mcu_as_sc_mcu7t3v3_, pplus, [(-0.08,1.77,14.08,4.15)])
R(gf180mcu_as_sc_mcu7t3v3_, nplus, [(-0.08,-0.23,14.08,1.77)])
A(gf180mcu_as_sc_mcu7t3v3_, contact, 6.61, 0.41, 0.22, 0.22, 5, 1, 1.6, 0)
A(gf180mcu_as_sc_mcu7t3v3_, contact, 7.41, 0.995, 0.22, 0.22, 4, 1, 1.6, 0)
A(gf180mcu_as_sc_mcu7t3v3_, contact, 0.705, 1.64, 0.22, 0.22, 4, 1, 0.47, 0)
A(gf180mcu_as_sc_mcu7t3v3_, contact, 3.255, 1.64, 0.22, 0.22, 5, 1, 0.47, 0)
A(gf180mcu_as_sc_mcu7t3v3_, contact, 7.105, 1.64, 0.22, 0.22, 4, 1, 0.47, 0)
A(gf180mcu_as_sc_mcu7t3v3_, contact, 9.66, 1.67, 0.22, 0.22, 5, 1, 0.47, 0)
A(gf180mcu_as_sc_mcu7t3v3_, contact, 1.81, 2.775, 0.22, 0.22, 3, 1, 1.6, 0)
A(gf180mcu_as_sc_mcu7t3v3_, contact, 1.01, 3.29, 0.22, 0.22, 4, 1, 1.6, 0)
R(gf180mcu_as_sc_mcu7t3v3_, contact, [(0.21,0.41,0.43,0.63), (1.81,0.41,2.03,0.63), (4.21,0.535,4.43,0.755), (5.81,0.535,6.03,0.755), (2.61,0.59,2.83,0.81), (1.01,0.865,1.23,1.085), (3.41,0.995,3.63,1.215), (5.01,0.995,5.23,1.215), (6.21,1.655,6.43,1.875), (12.61,1.655,12.83,1.875), (7.41,2.27,7.63,2.49), (10.61,2.27,10.83,2.49), (9.81,2.75,10.03,2.97), (11.41,2.75,11.63,2.97), (6.61,2.83,6.83,3.05), (0.21,2.995,0.43,3.215), (13.01,3.045,13.23,3.265), (8.21,3.165,8.43,3.385)])
A(gf180mcu_as_sc_mcu7t3v3_, metal1, 6.605, 0.3, 0.23, 0.39, 5, 1, 1.6, 0)
A(gf180mcu_as_sc_mcu7t3v3_, metal1, 1.005, 3.23, 0.23, 0.39, 4, 1, 1.6, 0)
R(gf180mcu_as_sc_mcu7t3v3_, metal1, [(0,-0.3,14,0.3), (0.205,0.3,0.435,0.69), (1.805,0.3,2.035,0.69), (2.605,0.53,6.095,0.76), (2.605,0.76,2.835,0.92), (1.005,0.79,1.235,0.92), (1.005,0.92,2.835,1.15), (3.35,0.99,13.475,1.22), (13.13,1.22,13.475,2.47), (2.98,1.565,5.565,1.96), (6.98,1.565,8.885,1.955), (6.205,1.57,6.435,2.215), (0.58,1.575,2.46,1.975), (12.485,1.59,12.9,1.94), (9.38,1.6,12.015,1.94), (2.125,1.975,2.46,2.215), (2.125,2.215,6.435,2.445), (7.35,2.24,10.89,2.47), (7.35,2.47,7.69,2.495), (10.55,2.47,10.89,2.495), (12.14,2.47,13.475,2.7), (12.14,2.7,12.37,2.745), (9.75,2.745,12.37,2.975), (0.205,2.77,6.835,3), (12.915,2.93,13.235,3.39), (8.205,2.955,8.595,3.16), (0.205,3,0.435,3.39), (6.605,3,6.835,3.16), (6.605,3.16,8.595,3.39), (0,3.62,14,4.22)])
R(gf180mcu_as_sc_mcu7t3v3_, metal1_pin, [(0,-0.3,14,0.3), (13.13,0.99,13.475,2.7), (2.98,1.565,5.565,1.96), (6.98,1.565,8.565,1.955), (0.58,1.575,2.46,1.975), (9.38,1.6,12.015,1.94), (0,3.62,14,4.22)])
R(gf180mcu_as_sc_mcu7t3v3_, via1, [(8.565,1.585,8.825,1.845), (12.59,1.63,12.85,1.89), (12.94,2.99,13.2,3.25), (8.28,3.025,8.54,3.285)])
R(gf180mcu_as_sc_mcu7t3v3_, metal2, [(8.555,1.04,12.86,1.32), (8.555,1.32,8.885,1.905), (12.58,1.32,12.86,1.95), (12.88,2.93,13.225,2.955), (8.22,2.955,13.225,3.235), (8.22,3.235,8.6,3.305), (12.88,3.235,13.225,3.31)])
R(gf180mcu_as_sc_mcu7t3v3_, lvpwell, [(-0.43,-0.43,14.43,1.77)])
R(gf180mcu_as_sc_mcu7t3v3_, lvpwell_10, [(0.05,-0.25,0.55,0.25)])
gf180mcu_as_sc_mcu7t3v3_.add(gdstk.Label('VDD', (7,3.92), layer=34, texttype=10))
gf180mcu_as_sc_mcu7t3v3_.add(gdstk.Label('VNW', (0.3,3.92), layer=21, texttype=10))
gf180mcu_as_sc_mcu7t3v3_.add(gdstk.Label('VPW', (0.3,0), layer=204, texttype=10))
gf180mcu_as_sc_mcu7t3v3_.add(gdstk.Label('VSS', (7,0), layer=34, texttype=10))
gf180mcu_as_sc_mcu7t3v3_.add(gdstk.Label('A', (1.52,1.775), layer=34, texttype=10))
gf180mcu_as_sc_mcu7t3v3_.add(gdstk.Label('B', (4.272,1.762), layer=34, texttype=10))
gf180mcu_as_sc_mcu7t3v3_.add(gdstk.Label('C', (7.772,1.76), layer=34, texttype=10))
gf180mcu_as_sc_mcu7t3v3_.add(gdstk.Label('D', (10.697,1.77), layer=34, texttype=10))
gf180mcu_as_sc_mcu7t3v3_.add(gdstk.Label('Y', (13.302,1.845), layer=34, texttype=10))

lib.write_gds('gf180mcu_as_sc_mcu7t3v3__aoi211_4.gds')
