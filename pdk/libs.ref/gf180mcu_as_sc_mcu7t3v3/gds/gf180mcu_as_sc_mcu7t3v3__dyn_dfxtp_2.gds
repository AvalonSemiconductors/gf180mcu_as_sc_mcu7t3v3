* Circuit, read from the shapes
.subckt gf180mcu_as_sc_mcu7t3v3__dyn_dfxtp_2 CLK D Q VDD VNW VSS
XM1 VSS CLK n1 VSUBS nfet_03v3 w=1u l=0.28u
XM2 n2 n1 VSS VSUBS nfet_03v3 w=1u l=0.28u
XM3 VSS D n3 VSUBS nfet_03v3 w=1u l=0.28u
XM4 n4 n3 VSS VSUBS nfet_03v3 w=1u l=0.28u
XM5 n5 n1 n4 VSUBS nfet_03v3 w=1u l=0.28u
XM6 n6 n5 VSS VSUBS nfet_03v3 w=1u l=0.28u
XM7 n7 n2 n6 VSUBS nfet_03v3 w=1u l=0.28u
XM8 Q n7 VSS VSUBS nfet_03v3 w=1u l=0.28u m=2
XM9 VDD CLK n1 VNW pfet_03v3 w=1.38u l=0.28u
XM10 n2 n1 VDD VNW pfet_03v3 w=1.38u l=0.28u
XM11 VDD D n3 VNW pfet_03v3 w=1.38u l=0.28u
XM12 n8 n3 VDD VNW pfet_03v3 w=1.38u l=0.28u
XM13 n5 n2 n8 VNW pfet_03v3 w=1.38u l=0.28u
XM14 n9 n5 VDD VNW pfet_03v3 w=1.38u l=0.28u
XM15 n7 n1 n9 VNW pfet_03v3 w=1.38u l=0.28u
XM16 Q n7 VDD VNW pfet_03v3 w=1.38u l=0.28u m=2
.ends

# Layout, gdstk code
import gdstk
lib = gdstk.Library(unit=1e-6, precision=1e-09)
def R(c, l, rs):  # rectangles x0, y0, x1, y1
    for r in rs: c.add(gdstk.rectangle(r[:2], r[2:], *l))
def A(c, l, x, y, w, h, nx, ny, dx, dy):  # array of equal rectangles
    R(c, l, [(x+i*dx, y+j*dy, x+i*dx+w, y+j*dy+h) for i in range(nx) for j in range(ny)])
boundary = (0, 0)
nwell = (21, 0)
nwell_10 = (21, 10)
comp = (22, 0)
poly2 = (30, 0)
pplus = (31, 0)
nplus = (32, 0)
contact = (33, 0)
metal1 = (34, 0)
metal1_pin = (34, 10)
via1 = (35, 0)
metal2 = (36, 0)
lvpwell = (204, 0)
lvpwell_10 = (204, 10)

gf180mcu_as_sc_mcu7t3v3_ = lib.new_cell('gf180mcu_as_sc_mcu7t3v3__dyn_dfxtp_2')
R(gf180mcu_as_sc_mcu7t3v3_, boundary, [(0,0,11.2,3.92)])
R(gf180mcu_as_sc_mcu7t3v3_, nwell, [(-0.43,1.77,11.63,4.35)])
R(gf180mcu_as_sc_mcu7t3v3_, nwell_10, [(0.05,3.67,0.55,4.17)])
R(gf180mcu_as_sc_mcu7t3v3_, comp, [(0.14,0.34,2.1,1.34), (2.38,0.34,5.635,1.34), (5.915,0.34,8.31,1.34), (8.59,0.34,10.55,1.34), (0.14,2.2,2.1,3.58), (2.38,2.2,5.635,3.58), (5.915,2.2,8.31,3.58), (8.59,2.2,10.55,3.58)])
A(gf180mcu_as_sc_mcu7t3v3_, poly2, 3.6, 1.555, 0.36, 0.435, 3, 1, 0.6, 0)
R(gf180mcu_as_sc_mcu7t3v3_, poly2, [(0.58,0.12,0.86,1.54), (1.38,0.12,1.66,1.54), (2.82,0.12,3.1,1.555), (3.62,0.12,3.9,1.555), (4.88,0.12,5.16,1.555), (6.355,0.12,6.635,1.575), (7.555,0.12,7.835,1.575), (9.03,0.12,9.31,1.545), (9.83,0.12,10.11,1.595), (0.3,1.54,0.86,1.945), (1.1,1.54,1.66,1.945), (8.37,1.545,9.31,1.595), (2.82,1.555,3.245,1.99), (5.755,1.575,6.635,2.01), (6.875,1.575,7.235,2.01), (7.475,1.575,7.835,2.01), (8.37,1.595,10.11,1.9), (8.37,1.9,9.31,1.98), (9.83,1.9,10.11,3.8), (0.58,1.945,0.86,3.8), (1.38,1.945,1.66,3.8), (9.03,1.98,9.31,3.8), (2.82,1.99,3.1,3.8), (3.62,1.99,3.9,3.8), (4.2,1.99,4.48,3.8), (6.355,2.01,6.635,3.8), (6.955,2.01,7.235,3.8)])
R(gf180mcu_as_sc_mcu7t3v3_, pplus, [(-0.08,1.77,11.28,4.15)])
R(gf180mcu_as_sc_mcu7t3v3_, nplus, [(-0.08,-0.23,11.28,1.77)])
A(gf180mcu_as_sc_mcu7t3v3_, contact, 8.66, 2.31, 0.22, 0.22, 1, 3, 0, 0.47)
A(gf180mcu_as_sc_mcu7t3v3_, contact, 10.26, 2.31, 0.22, 0.22, 1, 3, 0, 0.47)
R(gf180mcu_as_sc_mcu7t3v3_, contact, [(1.01,0.41,1.23,0.63), (3.25,0.41,3.47,0.63), (5.985,0.41,6.205,0.63), (8.66,0.41,8.88,0.63), (10.26,0.495,10.48,0.715), (10.26,0.965,10.48,1.185), (0.21,1,0.43,1.22), (1.81,1.05,2.03,1.27), (2.45,1.05,2.67,1.27), (5.345,1.05,5.565,1.27), (8.02,1.05,8.24,1.27), (9.46,1.05,9.68,1.27), (0.43,1.63,0.65,1.85), (1.17,1.635,1.39,1.855), (3.67,1.65,3.89,1.87), (4.27,1.65,4.49,1.87), (8.48,1.65,8.7,1.87), (4.87,1.655,5.09,1.875), (2.955,1.66,3.175,1.88), (7.545,1.66,7.765,1.88), (5.825,1.67,6.045,1.89), (6.945,1.675,7.165,1.895), (1.81,2.27,2.03,2.49), (2.45,2.27,2.67,2.49), (5.345,2.455,5.565,2.675), (8.02,2.455,8.24,2.675), (9.46,2.455,9.68,2.675), (0.21,2.595,0.43,2.815), (5.345,2.925,5.565,3.145), (8.02,2.925,8.24,3.145), (9.46,2.925,9.68,3.145), (1.01,3.29,1.23,3.51), (3.25,3.29,3.47,3.51), (5.985,3.29,6.205,3.51)])
R(gf180mcu_as_sc_mcu7t3v3_, metal1, [(0,-0.3,11.2,0.3), (1.005,0.3,1.235,0.69), (3.245,0.3,3.475,0.69), (5.98,0.3,6.21,0.69), (8.655,0.3,8.885,0.69), (10.255,0.3,10.485,1.395), (0.205,0.895,0.435,0.995), (2.445,0.92,3.895,1.15), (1.05,0.985,1.435,0.995), (1.805,0.99,2.035,2.265), (5.34,0.99,5.57,1.575), (8.015,0.99,8.245,1.545), (9.425,0.99,9.835,3.39), (0.205,0.995,1.435,1.225), (2.445,1.15,2.675,2.55), (3.665,1.15,3.895,1.99), (0.205,1.225,0.435,1.28), (1.05,1.225,1.435,1.305), (1.13,1.305,1.365,1.54), (4.265,1.445,4.495,1.57), (4.865,1.445,5.095,1.58), (6.94,1.445,7.17,1.595), (7.54,1.445,7.77,1.58), (0.175,1.54,0.8,1.945), (1.1,1.54,1.395,1.945), (8.015,1.545,8.8,1.98), (2.905,1.555,3.31,2.59), (4.25,1.57,4.51,1.95), (5.34,1.575,6.1,2.01), (4.85,1.58,5.11,1.96), (7.525,1.58,7.785,1.96), (6.925,1.595,7.185,1.975), (1.13,1.945,1.365,2.59), (4.265,1.95,4.495,2.075), (4.865,1.96,5.095,2.075), (7.54,1.96,7.77,2.075), (6.94,1.975,7.17,2.075), (8.015,1.98,8.245,3.39), (5.34,2.01,5.57,3.39), (10.255,2.13,10.485,3.62), (8.655,2.21,8.885,3.62), (1.75,2.265,2.09,2.495), (1.805,2.495,2.035,2.875), (0.205,2.535,0.435,2.59), (0.205,2.59,1.365,2.82), (0.205,2.82,0.435,2.875), (1.79,2.875,2.05,3.255), (1.005,3.23,1.235,3.62), (3.245,3.23,3.475,3.62), (5.98,3.23,6.21,3.62), (0,3.62,11.2,4.22)])
R(gf180mcu_as_sc_mcu7t3v3_, metal1_pin, [(0,-0.3,11.2,0.3), (9.425,0.99,9.835,3.39), (0.175,1.54,0.8,1.945), (2.905,1.555,3.31,2.59), (0,3.62,11.2,4.22)])
R(gf180mcu_as_sc_mcu7t3v3_, via1, [(1.115,0.985,1.375,1.245), (4.25,1.63,4.51,1.89), (4.85,1.64,5.11,1.9), (7.525,1.64,7.785,1.9), (6.925,1.655,7.185,1.915), (1.79,2.935,2.05,3.195)])
R(gf180mcu_as_sc_mcu7t3v3_, metal2, [(1.105,0.69,7.195,0.97), (1.105,0.97,1.385,1.305), (4.84,0.97,5.12,1.96), (6.915,0.97,7.195,1.975), (4.24,1.445,4.52,2.385), (7.515,1.58,7.795,2.385), (4.24,2.385,7.795,2.665), (4.24,2.665,4.52,2.925), (1.73,2.925,4.52,3.205)])
R(gf180mcu_as_sc_mcu7t3v3_, lvpwell, [(-0.43,-0.43,11.63,1.77)])
R(gf180mcu_as_sc_mcu7t3v3_, lvpwell_10, [(0.05,-0.25,0.55,0.25)])
gf180mcu_as_sc_mcu7t3v3_.add(gdstk.Label('VDD', (5.6,3.92), layer=34, texttype=10))
gf180mcu_as_sc_mcu7t3v3_.add(gdstk.Label('VNW', (0.3,3.92), layer=21, texttype=10))
gf180mcu_as_sc_mcu7t3v3_.add(gdstk.Label('VPW', (0.3,0), layer=204, texttype=10))
gf180mcu_as_sc_mcu7t3v3_.add(gdstk.Label('VSS', (5.6,0), layer=34, texttype=10))
gf180mcu_as_sc_mcu7t3v3_.add(gdstk.Label('CLK', (0.487,1.742), layer=34, texttype=10))
gf180mcu_as_sc_mcu7t3v3_.add(gdstk.Label('D', (3.107,2.072), layer=34, texttype=10))
gf180mcu_as_sc_mcu7t3v3_.add(gdstk.Label('Q', (9.63,2.19), layer=34, texttype=10))

lib.write_gds('gf180mcu_as_sc_mcu7t3v3__dyn_dfxtp_2.gds')
