* Circuit, read from the shapes
.subckt gf180mcu_as_sc_mcu7t3v3__mux4_2 A B C D S0 S1 VDD VNW VSS Y
XM1 n1 C VSS VSUBS nfet_03v3 w=1u l=0.28u
XM2 n2 n3 n1 VSUBS nfet_03v3 w=1u l=0.28u
XM3 n4 S0 n2 VSUBS nfet_03v3 w=1u l=0.28u
XM4 VSS D n4 VSUBS nfet_03v3 w=1u l=0.28u
XM5 Y n5 VSS VSUBS nfet_03v3 w=1u l=0.28u m=2
XM6 n5 S1 n2 VSUBS nfet_03v3 w=1u l=0.28u
XM7 n6 n7 n5 VSUBS nfet_03v3 w=1u l=0.28u
XM8 VSS S1 n7 VSUBS nfet_03v3 w=1u l=0.28u
XM9 n8 B VSS VSUBS nfet_03v3 w=1u l=0.28u
XM10 n6 S0 n8 VSUBS nfet_03v3 w=1u l=0.28u
XM11 n9 n3 n6 VSUBS nfet_03v3 w=1u l=0.28u
XM12 VSS A n9 VSUBS nfet_03v3 w=1u l=0.28u
XM13 n3 S0 VSS VSUBS nfet_03v3 w=1u l=0.28u
XM14 n1 C VDD VNW pfet_03v3 w=1.38u l=0.28u
XM15 n2 S0 n1 VNW pfet_03v3 w=1.38u l=0.28u
XM16 n4 n3 n2 VNW pfet_03v3 w=1.38u l=0.28u
XM17 VDD D n4 VNW pfet_03v3 w=1.38u l=0.28u
XM18 Y n5 VDD VNW pfet_03v3 w=1.38u l=0.28u m=2
XM19 n5 n7 n2 VNW pfet_03v3 w=1.38u l=0.28u
XM20 n6 S1 n5 VNW pfet_03v3 w=1.38u l=0.28u
XM21 VDD S1 n7 VNW pfet_03v3 w=1.38u l=0.28u
XM22 n8 B VDD VNW pfet_03v3 w=1.38u l=0.28u
XM23 n6 n3 n8 VNW pfet_03v3 w=1.38u l=0.28u
XM24 n9 S0 n6 VNW pfet_03v3 w=1.38u l=0.28u
XM25 VDD A n9 VNW pfet_03v3 w=1.38u l=0.28u
XM26 n3 S0 VDD VNW pfet_03v3 w=1.38u l=0.28u
.ends

# Layout, gdstk code
import gdstk
lib = gdstk.Library(unit=1e-6, precision=1e-09)
def R(c, l, rs):  # rectangles x0, y0, x1, y1
    for r in rs: c.add(gdstk.rectangle(r[:2], r[2:], *l))
def A(c, l, x, y, w, h, nx, ny, dx, dy):  # array of equal rectangles
    R(c, l, [(x+i*dx, y+j*dy, x+i*dx+w, y+j*dy+h) for i in range(nx) for j in range(ny)])
boundary = (0, 0)
nwell = (21, 0)
nwell_10 = (21, 10)
comp = (22, 0)
poly2 = (30, 0)
pplus = (31, 0)
nplus = (32, 0)
contact = (33, 0)
metal1 = (34, 0)
metal1_pin = (34, 10)
via1 = (35, 0)
metal2 = (36, 0)
lvpwell = (204, 0)
lvpwell_10 = (204, 10)

gf180mcu_as_sc_mcu7t3v3_ = lib.new_cell('gf180mcu_as_sc_mcu7t3v3__mux4_2')
R(gf180mcu_as_sc_mcu7t3v3_, boundary, [(0,0,18.48,3.92)])
R(gf180mcu_as_sc_mcu7t3v3_, nwell, [(-0.43,1.77,18.91,4.35)])
R(gf180mcu_as_sc_mcu7t3v3_, nwell_10, [(0.05,3.67,0.55,4.17)])
R(gf180mcu_as_sc_mcu7t3v3_, comp, [(0.14,0.34,7.415,1.34), (7.695,0.34,11.09,1.34), (11.37,0.34,18.34,1.34), (0.14,2.2,7.415,3.58), (7.695,2.2,11.09,3.58), (11.37,2.2,18.34,3.58)])
A(gf180mcu_as_sc_mcu7t3v3_, poly2, 4.775, 0.12, 0.28, 1.48, 3, 1, 0.8, 0)
A(gf180mcu_as_sc_mcu7t3v3_, poly2, 4.775, 1.96, 0.28, 1.84, 3, 1, 0.8, 0)
R(gf180mcu_as_sc_mcu7t3v3_, poly2, [(0.58,0.12,0.86,1.55), (1.86,0.12,2.14,1.59), (3.865,0.12,4.145,1.59), (8.77,0.12,9.05,1.6), (9.57,0.12,9.85,1.6), (11.81,0.12,12.09,1.66), (12.61,0.12,12.89,1.6), (13.45,0.12,13.73,1.605), (15.035,0.12,15.315,1.605), (16.455,0.12,16.735,1.595), (17.265,0.12,17.545,1.6), (0.29,1.55,0.86,2.015), (1.86,1.59,2.22,1.95), (2.46,1.59,2.82,1.95), (3.26,1.59,3.62,1.95), (3.86,1.59,4.22,1.95), (15.555,1.59,15.915,1.95), (10.09,1.595,10.65,1.66), (16.455,1.595,17.025,1.955), (4.775,1.6,5.25,1.96), (5.575,1.6,8.515,1.96), (8.755,1.6,9.115,1.96), (9.37,1.6,9.85,1.96), (12.41,1.6,12.89,1.96), (17.265,1.6,17.76,1.96), (13.43,1.605,13.79,1.965), (14.03,1.605,15.315,1.835), (10.09,1.66,12.09,1.89), (14.03,1.835,14.39,1.965), (10.09,1.89,10.65,1.955), (11.81,1.89,12.09,3.8), (2.54,1.95,2.82,3.8), (3.34,1.95,3.62,3.8), (15.57,1.95,15.85,3.8), (10.37,1.955,10.65,3.8), (16.455,1.955,16.735,3.8), (9.57,1.96,9.85,3.8), (12.61,1.96,12.89,3.8), (17.265,1.96,17.545,3.8), (14.04,1.965,14.32,3.8), (0.58,2.015,0.86,3.8)])
R(gf180mcu_as_sc_mcu7t3v3_, pplus, [(-0.08,1.77,18.56,4.15)])
R(gf180mcu_as_sc_mcu7t3v3_, nplus, [(-0.08,-0.23,18.56,1.77)])
R(gf180mcu_as_sc_mcu7t3v3_, contact, [(0.21,0.41,0.43,0.63), (5.205,0.41,5.425,0.63), (6.805,0.41,7.025,0.63), (12.24,0.41,12.46,0.63), (16.885,0.41,17.105,0.63), (9.2,0.535,9.42,0.755), (2.29,0.57,2.51,0.79), (6.005,0.995,6.225,1.215), (1.01,1.05,1.23,1.27), (4.405,1.05,4.625,1.27), (7.765,1.05,7.985,1.27), (10.8,1.05,11.02,1.27), (11.44,1.05,11.66,1.27), (13.04,1.05,13.26,1.27), (14.56,1.05,14.78,1.27), (16.085,1.05,16.305,1.27), (17.93,1.05,18.15,1.27), (1.93,1.66,2.15,1.88), (2.53,1.66,2.75,1.88), (3.33,1.66,3.55,1.88), (3.93,1.66,4.15,1.88), (15.625,1.66,15.845,1.88), (10.16,1.665,10.38,1.885), (16.71,1.665,16.93,1.885), (4.96,1.67,5.18,1.89), (8.225,1.67,8.445,1.89), (8.825,1.67,9.045,1.89), (9.44,1.67,9.66,1.89), (12.48,1.67,12.7,1.89), (17.47,1.67,17.69,1.89), (0.36,1.675,0.58,1.895), (13.5,1.675,13.72,1.895), (14.1,1.675,14.32,1.895), (1.01,2.27,1.23,2.49), (4.405,2.27,4.625,2.49), (6.005,2.27,6.225,2.49), (7.765,2.27,7.985,2.49), (10.8,2.27,11.02,2.49), (11.44,2.27,11.66,2.49), (13.04,2.27,13.26,2.49), (14.56,2.27,14.78,2.49), (16.085,2.27,16.305,2.49), (17.93,2.27,18.15,2.49), (2.97,2.35,3.19,2.57), (10,2.775,10.22,2.995), (0.21,3.29,0.43,3.51), (5.205,3.29,5.425,3.51), (6.805,3.29,7.025,3.51), (12.24,3.29,12.46,3.51), (16.885,3.29,17.105,3.51)])
R(gf180mcu_as_sc_mcu7t3v3_, metal1, [(0,-0.3,18.48,0.3), (0.205,0.3,0.435,0.69), (5.2,0.3,5.43,0.69), (6.8,0.3,7.03,0.69), (12.235,0.3,12.465,0.69), (16.88,0.3,17.11,0.69), (8.22,0.53,9.48,0.76), (10.335,0.53,11.665,0.76), (1.465,0.565,2.57,0.795), (17.615,0.715,18.155,0.975), (8.22,0.76,8.45,2.77), (10.335,0.76,10.565,0.99), (11.435,0.76,11.665,2.55), (1.465,0.795,1.695,2.345), (17.925,0.975,18.155,2.55), (1.005,0.99,1.235,2.55), (4.4,0.99,4.63,2.265), (5.945,0.99,6.285,1.51), (7.76,0.99,7.99,2.77), (9.435,0.99,10.565,1.22), (10.795,0.99,11.025,2.78), (13.035,0.99,13.265,2.55), (14.555,0.99,14.785,3.02), (16.08,0.99,16.31,2.265), (2.525,1.025,4.155,1.255), (9.435,1.22,9.665,2.08), (13.495,1.24,13.755,1.62), (2.525,1.255,2.875,1.96), (3.925,1.255,4.155,1.58), (8.735,1.47,9.125,2.31), (10.155,1.47,10.385,2.31), (15.565,1.47,15.85,1.985), (17.465,1.47,17.695,2.725), (14.095,1.48,14.325,1.595), (1.925,1.485,2.155,1.58), (3.325,1.485,3.555,1.58), (4.915,1.51,5.325,2.045), (5.62,1.51,6.285,2.05), (0.2,1.545,0.62,2.03), (1.925,1.58,2.185,1.96), (3.31,1.58,3.57,1.96), (3.91,1.58,4.17,1.96), (14.065,1.595,14.325,1.975), (16.54,1.595,17.075,1.955), (12.055,1.6,12.745,1.96), (13.495,1.62,13.725,2.41), (1.925,1.96,2.155,2.115), (2.525,1.96,2.755,2.115), (3.325,1.96,3.555,2.115), (3.925,1.96,4.155,2.115), (14.095,1.975,14.325,2.11), (15.565,1.985,15.795,2.47), (5.945,2.05,6.285,2.495), (4.345,2.265,4.685,2.495), (16.025,2.265,16.365,2.495), (8.735,2.31,10.385,2.375), (1.465,2.345,3.25,2.575), (8.82,2.375,10.385,2.54), (13.495,2.41,13.815,2.79), (15.025,2.47,15.795,2.725), (2.965,2.575,3.25,2.77), (15.025,2.725,17.695,2.73), (15.565,2.73,17.695,2.955), (2.965,2.77,7.99,3), (8.22,2.77,10.28,3), (10.795,2.78,12.99,3.01), (12.755,3.01,12.99,3.02), (12.755,3.02,14.785,3.25), (0.205,3.23,0.435,3.62), (5.2,3.23,5.43,3.62), (6.8,3.23,7.03,3.62), (16.88,3.23,17.11,3.62), (12.18,3.285,12.52,3.62), (0,3.62,18.48,4.22)])
R(gf180mcu_as_sc_mcu7t3v3_, metal1_pin, [(0,-0.3,18.48,0.3), (2.525,1.025,2.875,1.86), (5.945,1.34,6.285,2.495), (8.735,1.47,9.125,2.375), (4.915,1.51,5.325,2.045), (5.62,1.51,5.945,2.05), (0.2,1.545,0.62,2.03), (16.54,1.595,17.075,1.955), (12.055,1.6,12.745,1.96), (0,3.62,18.48,4.22)])
R(gf180mcu_as_sc_mcu7t3v3_, via1, [(17.675,0.715,17.935,0.975), (13.495,1.3,13.755,1.56), (1.925,1.64,2.185,1.9), (3.31,1.64,3.57,1.9), (3.91,1.64,4.17,1.9), (14.065,1.655,14.325,1.915), (13.495,2.47,13.755,2.73), (15.085,2.47,15.345,2.73)])
R(gf180mcu_as_sc_mcu7t3v3_, metal2, [(3.9,0.705,13.765,0.985), (14.055,0.705,17.995,0.985), (3.9,0.985,4.18,1.96), (13.485,0.985,13.765,1.62), (14.055,0.985,14.335,1.9), (1.915,1.435,2.195,2.34), (3.3,1.58,3.58,2.34), (12.875,1.9,14.335,2.18), (12.875,2.18,13.155,2.895), (1.915,2.34,3.58,2.62), (13.435,2.46,15.405,2.74), (3.3,2.62,3.58,2.895), (3.3,2.895,13.155,3.175)])
R(gf180mcu_as_sc_mcu7t3v3_, lvpwell, [(-0.43,-0.43,18.91,1.77)])
R(gf180mcu_as_sc_mcu7t3v3_, lvpwell_10, [(0.05,-0.25,0.55,0.25)])
gf180mcu_as_sc_mcu7t3v3_.add(gdstk.Label('VDD', (9.24,3.92), layer=34, texttype=10))
gf180mcu_as_sc_mcu7t3v3_.add(gdstk.Label('VNW', (0.3,3.92), layer=21, texttype=10))
gf180mcu_as_sc_mcu7t3v3_.add(gdstk.Label('VPW', (0.3,0), layer=204, texttype=10))
gf180mcu_as_sc_mcu7t3v3_.add(gdstk.Label('VSS', (9.24,0), layer=34, texttype=10))
gf180mcu_as_sc_mcu7t3v3_.add(gdstk.Label('C', (0.41,1.787), layer=34, texttype=10))
gf180mcu_as_sc_mcu7t3v3_.add(gdstk.Label('D', (5.12,1.777), layer=34, texttype=10))
gf180mcu_as_sc_mcu7t3v3_.add(gdstk.Label('Y', (5.782,1.78), layer=34, texttype=10))
gf180mcu_as_sc_mcu7t3v3_.add(gdstk.Label('Y', (6.115,1.917), layer=34, texttype=10))
gf180mcu_as_sc_mcu7t3v3_.add(gdstk.Label('B', (12.4,1.78), layer=34, texttype=10))
gf180mcu_as_sc_mcu7t3v3_.add(gdstk.Label('A', (16.807,1.775), layer=34, texttype=10))
gf180mcu_as_sc_mcu7t3v3_.add(gdstk.Label('S0', (2.7,1.442), layer=34, texttype=10))
gf180mcu_as_sc_mcu7t3v3_.add(gdstk.Label('S1', (8.93,1.922), layer=34, texttype=10))

lib.write_gds('gf180mcu_as_sc_mcu7t3v3__mux4_2.gds')
