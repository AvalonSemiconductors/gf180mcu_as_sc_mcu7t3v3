* Circuit, read from the shapes
.subckt gf180mcu_as_sc_mcu7t3v3__dlybuff_4 A VDD VNW VSS Y
XM1 VSS A n1 VSUBS nfet_03v3 w=0.36u l=0.28u
XM2 n2 n1 VSS VSUBS nfet_03v3 w=0.36u l=0.28u
XM3 n3 n1 n2 VSUBS nfet_03v3 w=0.36u l=0.28u
XM4 VSS n3 n4 VSUBS nfet_03v3 w=0.36u l=0.28u
XM5 Y n4 VSS VSUBS nfet_03v3 w=1u l=0.28u m=4
XM6 VDD A n1 VNW pfet_03v3 w=0.59u l=0.28u
XM7 n5 n1 VDD VNW pfet_03v3 w=0.59u l=0.28u
XM8 n3 n1 n5 VNW pfet_03v3 w=0.59u l=0.28u
XM9 VDD n3 n4 VNW pfet_03v3 w=0.59u l=0.28u
XM10 Y n4 VDD VNW pfet_03v3 w=1.38u l=0.28u m=4
.ends

# Layout, gdstk code
import gdstk
lib = gdstk.Library(unit=1e-6, precision=1e-09)
def R(c, l, rs):  # rectangles x0, y0, x1, y1
    for r in rs: c.add(gdstk.rectangle(r[:2], r[2:], *l))
def A(c, l, x, y, w, h, nx, ny, dx, dy):  # array of equal rectangles
    R(c, l, [(x+i*dx, y+j*dy, x+i*dx+w, y+j*dy+h) for i in range(nx) for j in range(ny)])
boundary = (0, 0)
nwell = (21, 0)
nwell_10 = (21, 10)
comp = (22, 0)
poly2 = (30, 0)
pplus = (31, 0)
nplus = (32, 0)
contact = (33, 0)
metal1 = (34, 0)
metal1_pin = (34, 10)
lvpwell = (204, 0)
lvpwell_10 = (204, 10)

gf180mcu_as_sc_mcu7t3v3_ = lib.new_cell('gf180mcu_as_sc_mcu7t3v3__dlybuff_4')
R(gf180mcu_as_sc_mcu7t3v3_, boundary, [(0,0,7.84,3.92)])
R(gf180mcu_as_sc_mcu7t3v3_, nwell, [(-0.43,1.77,8.27,4.35)])
R(gf180mcu_as_sc_mcu7t3v3_, nwell_10, [(0.05,3.67,0.55,4.17)])
R(gf180mcu_as_sc_mcu7t3v3_, comp, [(0.14,0.34,2.86,0.7), (3.14,0.34,7.7,0.7), (0.14,0.7,0.5,1.115), (2.5,0.7,2.86,1.115), (3.14,0.7,3.5,1.115), (4.18,0.7,7.7,1.34), (4.18,2.2,7.7,2.99), (0.14,2.575,0.5,2.99), (2.5,2.575,2.86,2.99), (3.14,2.575,3.5,2.99), (0.14,2.99,2.86,3.58), (3.14,2.99,7.7,3.58)])
A(gf180mcu_as_sc_mcu7t3v3_, poly2, 5.3, 0.12, 0.28, 1.525, 3, 1, 0.8, 0)
A(gf180mcu_as_sc_mcu7t3v3_, poly2, 5.3, 1.93, 0.28, 1.87, 3, 1, 0.8, 0)
R(gf180mcu_as_sc_mcu7t3v3_, poly2, [(0.7,0.12,0.98,1.385), (1.5,0.12,1.78,2.255), (2.02,0.12,2.3,2.255), (3.7,0.12,3.98,1.6), (4.5,0.12,4.78,1.565), (0.7,1.385,1.13,1.965), (4.22,1.565,4.78,1.645), (3.085,1.6,3.98,1.96), (4.22,1.645,7.18,1.93), (4.22,1.93,4.78,2.025), (3.7,1.96,3.98,3.8), (0.7,1.965,0.98,3.8), (4.5,2.025,4.78,3.8), (1.5,2.255,2.3,2.615), (1.5,2.615,1.78,3.8), (2.02,2.615,2.3,3.8)])
R(gf180mcu_as_sc_mcu7t3v3_, pplus, [(-0.08,1.77,7.92,4.15)])
R(gf180mcu_as_sc_mcu7t3v3_, nplus, [(-0.08,-0.23,7.92,1.77)])
A(gf180mcu_as_sc_mcu7t3v3_, contact, 5.73, 2.31, 0.22, 0.22, 1, 3, 0, 0.47)
A(gf180mcu_as_sc_mcu7t3v3_, contact, 7.33, 2.31, 0.22, 0.22, 1, 3, 0, 0.47)
R(gf180mcu_as_sc_mcu7t3v3_, contact, [(1.13,0.41,1.35,0.63), (4.13,0.41,4.35,0.63), (5.73,0.495,5.95,0.715), (7.33,0.495,7.55,0.715), (0.21,0.825,0.43,1.045), (2.57,0.825,2.79,1.045), (3.21,0.825,3.43,1.045), (5.73,0.965,5.95,1.185), (7.33,0.965,7.55,1.185), (4.93,1.05,5.15,1.27), (6.53,1.05,6.75,1.27), (0.78,1.555,1,1.775), (3.155,1.67,3.375,1.89), (4.29,1.685,4.51,1.905), (1.79,2.325,2.01,2.545), (4.93,2.455,5.15,2.675), (6.53,2.455,6.75,2.675), (0.21,2.645,0.43,2.865), (2.57,2.645,2.79,2.865), (3.21,2.645,3.43,2.865), (4.93,2.925,5.15,3.145), (6.53,2.925,6.75,3.145), (1.13,3.29,1.35,3.51), (4.13,3.29,4.35,3.51)])
R(gf180mcu_as_sc_mcu7t3v3_, metal1, [(0,-0.3,7.84,0.3), (1.125,0.3,1.355,0.69), (4.125,0.3,4.355,0.69), (5.725,0.3,5.955,1.415), (7.325,0.3,7.555,1.39), (0.205,0.765,0.435,2.64), (2.565,0.765,2.795,1.665), (3.145,0.82,3.895,1.05), (4.89,0.985,5.245,1.645), (6.48,0.985,6.835,1.645), (3.665,1.05,3.895,1.33), (0.7,1.185,1.13,2.175), (3.665,1.33,4.515,1.56), (4.285,1.56,4.515,2.64), (4.89,1.645,6.835,1.93), (2.565,1.665,3.46,1.895), (2.565,1.895,2.795,2.925), (4.89,1.93,5.245,3.39), (6.48,1.93,6.835,3.39), (5.725,2.16,5.955,3.62), (7.325,2.16,7.555,3.62), (1.785,2.22,2.015,2.64), (0.205,2.64,2.015,2.87), (3.15,2.64,4.515,2.87), (0.205,2.87,0.435,2.925), (1.125,3.23,1.355,3.62), (4.125,3.23,4.355,3.62), (0,3.62,7.84,4.22)])
R(gf180mcu_as_sc_mcu7t3v3_, metal1_pin, [(0,-0.3,7.84,0.3), (4.89,0.985,5.245,3.39), (6.48,0.985,6.835,3.39), (0.7,1.185,1.13,2.175), (0,3.62,7.84,4.22)])
R(gf180mcu_as_sc_mcu7t3v3_, lvpwell, [(-0.43,-0.43,8.27,1.77)])
R(gf180mcu_as_sc_mcu7t3v3_, lvpwell_10, [(0.05,-0.25,0.55,0.25)])
gf180mcu_as_sc_mcu7t3v3_.add(gdstk.Label('VDD', (3.92,3.92), layer=34, texttype=10))
gf180mcu_as_sc_mcu7t3v3_.add(gdstk.Label('VNW', (0.3,3.92), layer=21, texttype=10))
gf180mcu_as_sc_mcu7t3v3_.add(gdstk.Label('VPW', (0.3,0), layer=204, texttype=10))
gf180mcu_as_sc_mcu7t3v3_.add(gdstk.Label('VSS', (3.92,0), layer=34, texttype=10))
gf180mcu_as_sc_mcu7t3v3_.add(gdstk.Label('Y', (6.657,2.187), layer=34, texttype=10))
gf180mcu_as_sc_mcu7t3v3_.add(gdstk.Label('Y', (5.067,2.187), layer=34, texttype=10))
gf180mcu_as_sc_mcu7t3v3_.add(gdstk.Label('A', (0.915,1.68), layer=34, texttype=10))

lib.write_gds('gf180mcu_as_sc_mcu7t3v3__dlybuff_4.gds')
