* Circuit, read from the shapes
.subckt gf180mcu_as_sc_mcu7t3v3__buff_8 A VDD VNW VSS Y
XM1 VSS A n1 VSUBS nfet_03v3 w=1u l=0.28u m=3
XM2 Y n1 VSS VSUBS nfet_03v3 w=1u l=0.28u m=8
XM3 VDD A n1 VNW pfet_03v3 w=1.38u l=0.28u m=3
XM4 Y n1 VDD VNW pfet_03v3 w=1.38u l=0.28u m=8
.ends

# Layout, gdstk code
import gdstk
lib = gdstk.Library(unit=1e-6, precision=1e-09)
def R(c, l, rs):  # rectangles x0, y0, x1, y1
    for r in rs: c.add(gdstk.rectangle(r[:2], r[2:], *l))
def A(c, l, x, y, w, h, nx, ny, dx, dy):  # array of equal rectangles
    R(c, l, [(x+i*dx, y+j*dy, x+i*dx+w, y+j*dy+h) for i in range(nx) for j in range(ny)])
boundary = (0, 0)
nwell = (21, 0)
nwell_10 = (21, 10)
comp = (22, 0)
poly2 = (30, 0)
pplus = (31, 0)
nplus = (32, 0)
contact = (33, 0)
metal1 = (34, 0)
metal1_pin = (34, 10)
lvpwell = (204, 0)
lvpwell_10 = (204, 10)

gf180mcu_as_sc_mcu7t3v3_ = lib.new_cell('gf180mcu_as_sc_mcu7t3v3__buff_8')
R(gf180mcu_as_sc_mcu7t3v3_, boundary, [(0,0,10.08,3.92)])
R(gf180mcu_as_sc_mcu7t3v3_, nwell, [(-0.43,1.77,10.51,4.35)])
R(gf180mcu_as_sc_mcu7t3v3_, nwell_10, [(0.05,3.67,0.55,4.17)])
R(gf180mcu_as_sc_mcu7t3v3_, comp, [(0.14,0.34,9.645,1.34), (0.14,2.2,9.645,3.58)])
A(gf180mcu_as_sc_mcu7t3v3_, poly2, 4.58, 0.12, 0.28, 1.54, 6, 1, 0.8, 0)
A(gf180mcu_as_sc_mcu7t3v3_, poly2, 4.58, 1.89, 0.28, 1.91, 6, 1, 0.8, 0)
R(gf180mcu_as_sc_mcu7t3v3_, poly2, [(0.58,0.12,0.86,1.61), (1.38,0.12,1.66,1.61), (2.18,0.12,2.46,1.725), (2.98,0.12,3.26,1.61), (3.78,0.12,4.06,1.61), (0.37,1.61,1.66,1.725), (2.72,1.61,4.06,1.66), (2.72,1.66,8.86,1.89), (0.37,1.725,2.46,1.965), (2.72,1.89,4.06,1.995), (0.37,1.965,1.66,2.06), (2.18,1.965,2.46,3.8), (2.98,1.995,3.26,3.8), (3.78,1.995,4.06,3.8), (0.58,2.06,0.86,3.8), (1.38,2.06,1.66,3.8)])
R(gf180mcu_as_sc_mcu7t3v3_, pplus, [(-0.08,1.77,10.16,4.15)])
R(gf180mcu_as_sc_mcu7t3v3_, nplus, [(-0.08,-0.23,10.16,1.77)])
A(gf180mcu_as_sc_mcu7t3v3_, contact, 5.81, 0.495, 0.22, 0.22, 3, 2, 1.6, 0.47)
A(gf180mcu_as_sc_mcu7t3v3_, contact, 1.81, 0.82, 0.22, 0.22, 5, 1, 1.6, 0)
A(gf180mcu_as_sc_mcu7t3v3_, contact, 2.61, 2.3, 0.22, 0.22, 1, 3, 0, 0.47)
A(gf180mcu_as_sc_mcu7t3v3_, contact, 9.01, 2.325, 0.22, 0.22, 1, 3, 0, 0.47)
A(gf180mcu_as_sc_mcu7t3v3_, contact, 5.01, 2.455, 0.22, 0.22, 3, 2, 1.6, 0.47)
R(gf180mcu_as_sc_mcu7t3v3_, contact, [(4.21,0.44,4.43,0.66), (1.01,0.45,1.23,0.67), (2.61,0.515,2.83,0.735), (0.21,0.87,0.43,1.09), (2.61,0.985,2.83,1.205), (3.005,1.685,3.225,1.905), (3.475,1.685,3.695,1.905), (0.48,1.72,0.7,1.94), (1.81,2.455,2.03,2.675), (3.41,2.46,3.63,2.68), (7.41,2.55,7.63,2.77), (5.81,2.555,6.03,2.775), (4.21,2.78,4.43,3), (0.21,2.815,0.43,3.035), (1.81,2.925,2.03,3.145), (3.41,2.93,3.63,3.15), (7.41,3.02,7.63,3.24), (5.81,3.025,6.03,3.245), (4.21,3.25,4.43,3.47), (1.01,3.255,1.23,3.475)])
A(gf180mcu_as_sc_mcu7t3v3_, metal1, 5.805, 0.3, 0.23, 1.04, 3, 1, 1.6, 0)
A(gf180mcu_as_sc_mcu7t3v3_, metal1, 5.005, 0.53, 0.23, 1.04, 3, 1, 1.6, 0)
A(gf180mcu_as_sc_mcu7t3v3_, metal1, 5.005, 1.98, 0.23, 1.41, 3, 1, 1.6, 0)
A(gf180mcu_as_sc_mcu7t3v3_, metal1, 5.805, 2.265, 0.23, 1.355, 3, 1, 1.6, 0)
R(gf180mcu_as_sc_mcu7t3v3_, metal1, [(0,-0.3,10.08,0.3), (1.005,0.3,1.235,0.735), (2.605,0.3,2.835,1.38), (4.205,0.3,4.435,0.735), (1.805,0.53,2.035,0.965), (3.405,0.53,3.635,1.2), (0.205,0.79,0.435,0.965), (0.205,0.965,2.035,1.195), (1.805,1.195,2.035,1.625), (3.405,1.2,4.44,1.43), (4.205,1.43,4.44,1.57), (0.285,1.455,0.665,1.61), (4.205,1.57,9.235,1.98), (0.285,1.61,0.77,2.06), (2.715,1.61,3.065,1.625), (1.805,1.625,3.065,1.66), (1.805,1.66,3.975,1.885), (1.805,1.885,2.035,2.725), (2.715,1.885,3.975,1.935), (2.715,1.935,3.065,1.995), (4.205,1.98,4.525,2.22), (0.285,2.06,0.665,2.405), (3.405,2.22,4.525,2.45), (2.605,2.225,2.835,3.62), (3.405,2.45,3.635,3.39), (4.205,2.68,4.435,3.62), (0.205,2.725,2.035,2.955), (0.205,2.955,0.435,3.115), (1.805,2.955,2.035,3.39), (1.005,3.185,1.235,3.62), (0,3.62,10.08,4.22)])
R(gf180mcu_as_sc_mcu7t3v3_, metal1_pin, [(0,-0.3,10.08,0.3), (0.285,1.455,0.665,2.405), (4.205,1.57,9.235,1.98), (0,3.62,10.08,4.22)])
R(gf180mcu_as_sc_mcu7t3v3_, lvpwell, [(-0.43,-0.43,10.51,1.77)])
R(gf180mcu_as_sc_mcu7t3v3_, lvpwell_10, [(0.05,-0.25,0.55,0.25)])
gf180mcu_as_sc_mcu7t3v3_.add(gdstk.Label('VDD', (5.04,3.92), layer=34, texttype=10))
gf180mcu_as_sc_mcu7t3v3_.add(gdstk.Label('VNW', (0.3,3.92), layer=21, texttype=10))
gf180mcu_as_sc_mcu7t3v3_.add(gdstk.Label('VPW', (0.3,0), layer=204, texttype=10))
gf180mcu_as_sc_mcu7t3v3_.add(gdstk.Label('VSS', (5.04,0), layer=34, texttype=10))
gf180mcu_as_sc_mcu7t3v3_.add(gdstk.Label('A', (0.475,1.93), layer=34, texttype=10))
gf180mcu_as_sc_mcu7t3v3_.add(gdstk.Label('Y', (6.72,1.775), layer=34, texttype=10))

lib.write_gds('gf180mcu_as_sc_mcu7t3v3__buff_8.gds')
