* Circuit, read from the shapes
.subckt gf180mcu_as_sc_mcu7t3v3__dfxtp_4 CLK D Q VDD VNW VSS
XM1 VSS CLK n1 VSUBS nfet_03v3 w=1u l=0.28u
XM2 n2 n1 VSS VSUBS nfet_03v3 w=1u l=0.28u
XM3 n3 n1 VSS VSUBS nfet_03v3 w=1u l=0.28u
XM4 n4 D n3 VSUBS nfet_03v3 w=1u l=0.28u
XM5 n5 n2 n4 VSUBS nfet_03v3 w=1u l=0.28u
XM6 VSS n6 n5 VSUBS nfet_03v3 w=1u l=0.28u
XM7 n6 n4 VSS VSUBS nfet_03v3 w=1u l=0.28u
XM8 n7 n2 n6 VSUBS nfet_03v3 w=1u l=0.28u
XM9 n8 n1 n7 VSUBS nfet_03v3 w=1u l=0.28u
XM10 VSS n9 n8 VSUBS nfet_03v3 w=1u l=0.28u
XM11 n9 n7 VSS VSUBS nfet_03v3 w=1u l=0.28u
XM12 Q n9 VSS VSUBS nfet_03v3 w=1u l=0.28u m=4
XM13 VDD CLK n1 VNW pfet_03v3 w=1.38u l=0.28u
XM14 n2 n1 VDD VNW pfet_03v3 w=1.38u l=0.28u
XM15 n10 n2 VDD VNW pfet_03v3 w=1.38u l=0.285u
XM16 n4 D n10 VNW pfet_03v3 w=1.38u l=0.28u
XM17 n11 n1 n4 VNW pfet_03v3 w=1.38u l=0.285u
XM18 VDD n6 n11 VNW pfet_03v3 w=1.38u l=0.28u
XM19 n6 n4 VDD VNW pfet_03v3 w=1.38u l=0.28u
XM20 n7 n1 n6 VNW pfet_03v3 w=1.38u l=0.28u
XM21 n12 n2 n7 VNW pfet_03v3 w=1.38u l=0.28u
XM22 VDD n9 n12 VNW pfet_03v3 w=1.38u l=0.28u
XM23 n9 n7 VDD VNW pfet_03v3 w=1.38u l=0.28u
XM24 Q n9 VDD VNW pfet_03v3 w=1.38u l=0.28u m=4
.ends

# Layout, gdstk code
import gdstk
lib = gdstk.Library(unit=1e-6, precision=1e-09)
def R(c, l, rs):  # rectangles x0, y0, x1, y1
    for r in rs: c.add(gdstk.rectangle(r[:2], r[2:], *l))
def A(c, l, x, y, w, h, nx, ny, dx, dy):  # array of equal rectangles
    R(c, l, [(x+i*dx, y+j*dy, x+i*dx+w, y+j*dy+h) for i in range(nx) for j in range(ny)])
boundary = (0, 0)
nwell = (21, 0)
nwell_10 = (21, 10)
comp = (22, 0)
poly2 = (30, 0)
pplus = (31, 0)
nplus = (32, 0)
contact = (33, 0)
metal1 = (34, 0)
metal1_pin = (34, 10)
via1 = (35, 0)
metal2 = (36, 0)
lvpwell = (204, 0)
lvpwell_10 = (204, 10)

gf180mcu_as_sc_mcu7t3v3_ = lib.new_cell('gf180mcu_as_sc_mcu7t3v3__dfxtp_4')
R(gf180mcu_as_sc_mcu7t3v3_, boundary, [(0,0,16.8,3.92)])
R(gf180mcu_as_sc_mcu7t3v3_, nwell, [(-0.43,1.77,17.23,4.35)])
R(gf180mcu_as_sc_mcu7t3v3_, nwell_10, [(0.05,3.67,0.55,4.17)])
R(gf180mcu_as_sc_mcu7t3v3_, comp, [(0.14,0.34,2.145,1.34), (2.425,0.34,12.565,1.34), (12.845,0.34,16.55,1.34), (0.14,2.2,2.145,3.58), (2.425,2.2,12.565,3.58), (12.845,2.2,16.55,3.58)])
A(gf180mcu_as_sc_mcu7t3v3_, poly2, 13.285, 0.12, 0.28, 1.5, 3, 1, 0.8, 0)
A(gf180mcu_as_sc_mcu7t3v3_, poly2, 13.285, 1.98, 0.28, 1.82, 3, 1, 0.8, 0)
R(gf180mcu_as_sc_mcu7t3v3_, poly2, [(0.58,0.12,0.86,1.6), (1.38,0.12,1.66,1.44), (2.865,0.12,3.145,1.44), (3.985,0.12,4.265,1.63), (6.015,0.12,6.295,1.63), (6.575,0.12,6.855,1.63), (7.375,0.12,7.655,1.625), (8.265,0.12,8.545,1.625), (9.795,0.12,10.075,1.625), (10.935,0.12,11.215,1.625), (11.735,0.12,12.015,1.62), (15.69,0.12,15.97,1.62), (1.38,1.44,3.145,1.595), (1.11,1.595,3.145,1.67), (0.5,1.6,0.86,1.97), (11.735,1.62,12.115,1.98), (12.355,1.62,15.97,1.98), (7.23,1.625,7.655,1.985), (8.26,1.625,8.62,1.985), (8.86,1.625,10.075,1.855), (10.315,1.625,10.695,1.985), (10.935,1.625,11.315,1.985), (3.385,1.63,3.745,1.99), (3.985,1.63,4.345,1.99), (5.035,1.63,5.415,1.99), (5.975,1.63,6.335,1.99), (6.575,1.63,6.935,1.99), (1.11,1.67,1.66,1.965), (8.86,1.855,9.22,1.985), (1.38,1.965,1.66,3.8), (0.58,1.97,0.86,3.8), (11.735,1.98,12.015,3.8), (15.69,1.98,15.97,3.8), (7.375,1.985,7.655,3.8), (8.86,1.985,9.14,3.8), (10.36,1.985,10.64,3.8), (10.935,1.985,11.215,3.8), (3.39,1.99,3.675,3.8), (3.985,1.99,4.265,3.8), (5.035,1.99,5.32,3.8), (6.575,1.99,6.855,3.8)])
R(gf180mcu_as_sc_mcu7t3v3_, pplus, [(-0.08,1.77,16.88,4.15)])
R(gf180mcu_as_sc_mcu7t3v3_, nplus, [(-0.08,-0.23,16.88,1.77)])
A(gf180mcu_as_sc_mcu7t3v3_, contact, 12.915, 2.31, 0.22, 0.22, 1, 3, 0, 0.47)
A(gf180mcu_as_sc_mcu7t3v3_, contact, 14.515, 2.31, 0.22, 0.22, 1, 3, 0, 0.47)
A(gf180mcu_as_sc_mcu7t3v3_, contact, 16.12, 2.31, 0.22, 0.22, 1, 3, 0, 0.47)
R(gf180mcu_as_sc_mcu7t3v3_, contact, [(1.01,0.41,1.23,0.63), (2.495,0.41,2.715,0.63), (7.005,0.41,7.225,0.63), (11.365,0.41,11.585,0.63), (12.915,0.495,13.135,0.715), (14.515,0.495,14.735,0.715), (16.12,0.495,16.34,0.715), (12.915,0.965,13.135,1.185), (14.515,0.965,14.735,1.185), (16.12,0.965,16.34,1.185), (0.21,1.05,0.43,1.27), (1.81,1.05,2.03,1.27), (4.665,1.05,4.885,1.27), (7.805,1.05,8.025,1.27), (9.425,1.05,9.645,1.27), (12.275,1.05,12.495,1.27), (13.715,1.05,13.935,1.27), (15.315,1.05,15.535,1.27), (1.18,1.665,1.4,1.885), (0.57,1.67,0.79,1.89), (11.815,1.69,12.035,1.91), (12.425,1.69,12.645,1.91), (7.305,1.695,7.525,1.915), (8.33,1.695,8.55,1.915), (8.93,1.695,9.15,1.915), (10.395,1.695,10.615,1.915), (11.015,1.695,11.235,1.915), (3.455,1.7,3.675,1.92), (4.055,1.7,4.275,1.92), (5.125,1.7,5.345,1.92), (6.045,1.7,6.265,1.92), (6.645,1.7,6.865,1.92), (1.81,2.27,2.03,2.49), (4.665,2.27,4.885,2.49), (7.805,2.27,8.025,2.49), (9.425,2.27,9.645,2.49), (13.715,2.27,13.935,2.49), (15.315,2.27,15.535,2.49), (12.275,2.455,12.495,2.675), (0.21,2.71,0.43,2.93), (12.275,2.925,12.495,3.145), (1.01,3.29,1.23,3.51), (2.495,3.29,2.715,3.51), (7.005,3.29,7.225,3.51), (11.365,3.29,11.585,3.51)])
R(gf180mcu_as_sc_mcu7t3v3_, metal1, [(0,-0.3,16.8,0.3), (1.005,0.3,1.235,0.69), (2.49,0.3,2.72,0.69), (7,0.3,7.23,0.69), (11.36,0.3,11.59,0.69), (12.91,0.3,13.14,1.39), (14.51,0.3,14.74,1.385), (16.115,0.3,16.345,1.385), (3.45,0.53,6.27,0.76), (3.45,0.76,3.68,1.64), (6.04,0.76,6.27,1.645), (9.42,0.92,12.04,1.15), (0.205,0.99,0.435,1.045), (1.805,0.99,2.035,1.77), (4.66,0.99,4.89,1.17), (6.655,0.99,8.03,1.22), (12.27,0.99,12.5,1.62), (13.615,0.99,14.045,1.62), (15.21,0.99,15.64,1.62), (0.205,1.045,1.335,1.275), (9.42,1.15,9.65,2.55), (11.81,1.15,12.04,1.98), (4.66,1.17,5.81,1.4), (6.655,1.22,6.885,1.64), (7.8,1.22,8.03,2.55), (0.205,1.275,0.435,1.33), (1.105,1.275,1.335,1.605), (4.66,1.4,4.89,2.55), (5.58,1.4,5.81,2.295), (8.87,1.56,9.19,2.025), (8.26,1.595,8.64,1.985), (0.125,1.6,0.86,2.06), (1.105,1.605,1.405,1.985), (12.27,1.62,12.65,1.98), (13.615,1.62,15.64,1.915), (7.3,1.625,7.53,2.295), (10.39,1.625,10.62,3.005), (11.01,1.625,11.24,2.27), (3.985,1.63,4.43,2.93), (5.12,1.63,5.35,3.16), (3.375,1.64,3.68,1.77), (6.625,1.64,6.885,1.99), (6.04,1.645,6.325,1.99), (1.805,1.77,3.68,2), (13.615,1.915,14.045,2.55), (15.21,1.915,15.64,2.55), (12.27,1.98,12.5,2.27), (1.105,1.985,1.335,2.705), (8.32,1.985,8.55,3.005), (6.045,1.99,6.325,2.025), (1.805,2,2.035,2.265), (12.91,2.145,13.14,3.62), (14.51,2.145,14.74,3.62), (16.115,2.145,16.345,3.62), (1.745,2.265,2.095,2.495), (11.01,2.27,12.5,2.5), (5.58,2.295,7.53,2.525), (12.27,2.5,12.5,3.39), (0.205,2.65,0.445,2.705), (0.205,2.705,1.335,2.77), (5.925,2.755,6.305,3.09), (0.205,2.77,3.2,2.935), (0.205,2.935,0.445,2.995), (1.105,2.935,3.2,3), (2.97,3,3.2,3.16), (8.32,3.005,10.62,3.235), (5.925,3.09,6.205,3.16), (2.97,3.16,6.205,3.39), (1.005,3.23,1.235,3.62), (2.49,3.23,2.72,3.62), (7,3.23,7.23,3.62), (11.36,3.23,11.59,3.62), (0,3.62,16.8,4.22)])
R(gf180mcu_as_sc_mcu7t3v3_, metal1_pin, [(0,-0.3,16.8,0.3), (13.615,0.99,14.045,2.55), (15.21,0.99,15.64,2.55), (0.125,1.6,0.86,2.06), (14.045,1.62,15.21,1.915), (3.985,1.63,4.43,2.93), (0,3.62,16.8,4.22)])
R(gf180mcu_as_sc_mcu7t3v3_, via1, [(8.93,1.7,9.19,1.96), (6.045,1.705,6.305,1.965), (8.32,1.705,8.58,1.965), (5.985,2.77,6.245,3.03)])
R(gf180mcu_as_sc_mcu7t3v3_, metal2, [(8.92,1.64,9.2,2.76), (6.045,1.645,6.325,1.695), (6.035,1.695,8.64,1.975), (6.045,1.975,6.325,2.025), (5.915,2.76,9.2,3.04)])
R(gf180mcu_as_sc_mcu7t3v3_, lvpwell, [(-0.43,-0.43,17.23,1.77)])
R(gf180mcu_as_sc_mcu7t3v3_, lvpwell_10, [(0.05,-0.25,0.55,0.25)])
gf180mcu_as_sc_mcu7t3v3_.add(gdstk.Label('VDD', (8.4,3.92), layer=34, texttype=10))
gf180mcu_as_sc_mcu7t3v3_.add(gdstk.Label('VNW', (0.3,3.92), layer=21, texttype=10))
gf180mcu_as_sc_mcu7t3v3_.add(gdstk.Label('VPW', (0.3,0), layer=204, texttype=10))
gf180mcu_as_sc_mcu7t3v3_.add(gdstk.Label('VSS', (8.4,0), layer=34, texttype=10))
gf180mcu_as_sc_mcu7t3v3_.add(gdstk.Label('CLK', (0.492,1.83), layer=34, texttype=10))
gf180mcu_as_sc_mcu7t3v3_.add(gdstk.Label('D', (4.207,2.28), layer=34, texttype=10))
gf180mcu_as_sc_mcu7t3v3_.add(gdstk.Label('Q', (14.627,1.767), layer=34, texttype=10))
gf180mcu_as_sc_mcu7t3v3_.add(gdstk.Label('Q', (15.425,1.77), layer=34, texttype=10))
gf180mcu_as_sc_mcu7t3v3_.add(gdstk.Label('Q', (13.83,1.77), layer=34, texttype=10))

lib.write_gds('gf180mcu_as_sc_mcu7t3v3__dfxtp_4.gds')
